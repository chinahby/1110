;============================================================================
;
;           M S M   R E G I S T E R  D E F I N I T I O N S
;
;                       *** AUTOGENERATED ***
;
; GENERAL DESCRIPTION
;   This file defines the MSM peripheral registers within Trace32.
;   It was generated with the following command options:
;   hwioreg.pl 
;     -f ARM_ADDRESS_FILE.FLAT 
;     -gen_parser 
;     -gen_per 
;     -cfg=msmreg.cfg 
;
; INITIALIZATION AND SEQUENCING REQUIREMENTS
;   Type the command "per [filename.per]" in Trace32 to view the registers.
;
;      Copyright (c) 2007 by QUALCOMM, Inc.  All Rights Reserved.
;============================================================================

config 16. 8.
width 6.

base ad:0x70000000
tree "ADSP"
  tree "ADSP_RAMA_BASE"
   group.long 0x0--0x3 "ADSP_RAMA_BASE (at 0x70000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RAM_DATA                       = "
  tree.end
  tree "ADSP_RAMB_BASE"
   group.long 0x200000--0x200003 "ADSP_RAMB_BASE (at 0x70200000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RAM_DATA                       = "
  tree.end
  tree "ADSP_RAMC_BASE"
   group.long 0x400000--0x400003 "ADSP_RAMC_BASE (at 0x70400000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RAM_DATA                       = "
  tree.end
  tree "ADSP_RAMI_BASE"
   group.long 0x800000--0x800003 "ADSP_RAMI_BASE (at 0x70800000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RAM_DATA                       = "
  tree.end
  tree "ADSP_CTL"
   group.long 0xc00000--0xc00003 "ADSP_CTL (at 0x70c00000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   QDSP4_ENCRYPTION_ENABLE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   FIRMWARE_RESET                 = " "0 (START),1 (DISABLE_AND_RESET) "
  tree.end
  tree "ADSP_CLK_GATE_CTL"
   group.long 0xc00010--0xc00013 "ADSP_CLK_GATE_CTL (at 0x70c00010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   AGU_CLK_OVR_N                  = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   AGUA_OVR_N                     = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   AGUB_OVR_N                     = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   AGUC_OVR_N                     = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   PCLK_OVR_N                     = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   REGFILE_CLK_OVR_N              = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   COPRO_CLK_OVR_N                = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   INTC_CLK_OVR_N                 = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   XMEMC_CLK_OVR_N                = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DME_CLK_OVR_N                  = " "0 (CLOCK_ON),1 (CLOCK_OFF) "
  tree.end
  tree "ADSP_CLK_STATUS"
   group.long 0xc00014--0xc00017 "ADSP_CLK_STATUS (at 0x70c00014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   AGU_CLK_OFF                    = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   AGUA_CLK_OFF                   = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   AGUB_CLK_OFF                   = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   AGUC_CLK_OFF                   = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DMA_CLK_OFF                    = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   XMEMC_CLK_OFF                  = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   RAM_CLK_OFF                    = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DBG_BUS_CLK_OFF                = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   COPRO_CLK_OFF                  = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   REGFILE_SHDW_CLK_OFF           = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   REGFILE_CLK_OFF                = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   PCLK_OFF                       = " "0 (ENABLED),1 (DISABLED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACLK_OFF                       = " "0 (ENABLED),1 (DISABLED) "
  tree.end
  tree "ADSP_DBG_CTRL"
   group.long 0xc0001c--0xc0001f "ADSP_DBG_CTRL (at 0x70c0001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DBG_BUS_RATE                   = "
  tree.end
  tree "ADSP_PC_DBG"
   group.long 0xc00020--0xc00023 "ADSP_PC_DBG (at 0x70c00020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x14 1 "  [20: 0]   PC_DBG                         = "
  tree.end
  tree "ADSP_INT_MASK_DBG"
   group.long 0xc00024--0xc00027 "ADSP_INT_MASK_DBG (at 0x70c00024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GLOBAL_DISABLE                 = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   INT_MASK                       = "
  tree.end
  tree "ADSP_INT_MASK2_DBG"
   group.long 0xc00028--0xc0002b "ADSP_INT_MASK2_DBG (at 0x70c00028)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GLOBAL_DISABLE                 = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   INT_MASK2                      = "
  tree.end
  tree "ADSP_MEM_ACC_CTRL"
   group.long 0xc0002c--0xc0002f "ADSP_MEM_ACC_CTRL (at 0x70c0002c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ACC_CTRL_ROM                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ACC_CTRL_RAM                   = "
  tree.end
tree.end

base ad:0x80002000
tree "AHB"
  tree "BOOT_ROM_CLOCK_ENABLE"
   group.long 0x0--0x3 "BOOT_ROM_CLOCK_ENABLE (at 0x80002000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BOOT_ROM_CLOCK_EN              = " "0 (DISABLED),1 (ENABLED) "
  tree.end
  tree "PAUSE_TIMER"
   group.long 0x20--0x23 "PAUSE_TIMER (at 0x80002020)   (shadowed - Use hwio_shadow_ptr->PAUSE_TIMER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PAUSE_TIMER                    = "
  tree.end
  tree "PAUSE_TIMER_CTL"
   group.long 0x28--0x2b "PAUSE_TIMER_CTL (at 0x80002028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   GATED_DHREADY                  = " "0 (GATED),1 (NOT_GATED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ARMCLK_HALT                    = " "0 (NOT_HALTED),1 (HALTED) "
  tree.end
  tree "BPM_TRIGGER"
   group.long 0x30--0x33 "BPM_TRIGGER (at 0x80002030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   PM_RUNSTOP_VFE_EN              = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PM_RUNSTOP_VFE_SEL             = " "0 (VIEW_AHB_INTR_SELECTED),1 (ENC_AHB_INTR_SELECTED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   PM_ACCUMULATE_UXMC_EN          = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   PM_ACCUMULATE_DME_EN           = " "0 (DISABLED),1 (ENABLED) "
  tree.end
  tree "BPM_HSEL_SEL"
   group.long 0x34--0x37 "BPM_HSEL_SEL (at 0x80002034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   APP_AHB                        = " "0 (FIRST_BUS),1 (SECOND_BUS) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SYS_AHB                        = " "0 (FIRST_BUS),1 (SECOND_BUS),2 (THIRD_BUS),3 (FOURTH_BUS) "
  tree.end
  tree "EBI1_CS0_CS1_SWAP"
   group.long 0x40--0x43 "EBI1_CS0_CS1_SWAP (at 0x80002040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EBI1_CS0_CS1_SWAP              = " "0 (DISABLED),1 (ENABLED) "
  tree.end
  tree "MSM_BRIDGE_CFG"
   group.long 0x4c--0x4f "MSM_BRIDGE_CFG (at 0x8000204c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   TIMEOUT_EN                     = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TIMEOUT_VALUE                  = "
  tree.end
  tree "AHB_TEST_BUS_CTL"
   group.long 0x68--0x6b "AHB_TEST_BUS_CTL (at 0x80002068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   AHB_TEST_GROUP_SELECT          = " "0 (SYS_AHB),1 (APP_AHB),2 (AHB_TEST_BUS_REG),3 (EBI),4 (BPM),5 (reserved),6 (reserved),7 (GSBI_AHB_CLK) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   AHB_TEST_BUS_ENABLE            = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "AHB_TEST_BUS"
   group.long 0x6c--0x6f "AHB_TEST_BUS (at 0x8000206c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   AHB_TEST_BUS_REG               = "
  tree.end
  tree "BOOT_FROM_ROM_STATUS"
   group.long 0x74--0x77 "BOOT_FROM_ROM_STATUS (at 0x80002074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BOOT_FROM_ROM                  = " "0 (BOOT_FROM_EXTERNAL_MEMORY),1 (BOOT_FROM_INTERNAL_BOOT_ROM) "
  tree.end
  tree "AHB_APP_BUS_PRIORITY"
   group.long 0x90--0x93 "AHB_APP_BUS_PRIORITY (at 0x80002090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   DEFAULT_MASTER                 = " "0 (DUMMY_SW),1 (BPM),2 (USB),3 (ADSP_DME),4 (SDCC),5 (VIDEO),6 (MDP),7 (GSBI_AHB_CLK) "
    textline ""
    bitfld.long 0x0 0x12--0x14 "  [20:18]   MDP_PRIORITY                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xf--0x11 "  [17:15]   VIDEO_PRIORITY                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   SDCC_PRIORITY                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   ADSP_PRIORITY                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   USB_PRIORITY                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPM_PRIORITY                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DUMMY_SW_PRIORITY              = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "AHB_BUS_REQUEST"
   group.long 0x98--0x9b "AHB_BUS_REQUEST (at 0x80002098) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   APP_HBUSREQ                    = " "0,1 "
  tree.end
  tree "AHB_BUS_MASTERS"
   group.long 0x9c--0x9f "AHB_BUS_MASTERS (at 0x8000209c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   APP_HMASTER                    = "
  tree.end
  tree "AHB_SYS_BUS_PRIORITY"
   group.long 0xe4--0xe7 "AHB_SYS_BUS_PRIORITY (at 0x800020e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEFAULT_MASTER                 = " "0 (ARMI),1 (ARMD),2 (TIC),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ARMI_PRIORITY                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ARMD_PRIORITY                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIC_PRIORITY                   = " "0,1,2,3 "
  tree.end
  tree "AHB_SYS_DUMMY0"
   group.long 0xe8--0xeb "AHB_SYS_DUMMY0 (at 0x800020e8) "
    line.long 0x0 "VALUE"
  tree.end
  tree "AHB_SYS_DUMMY1"
   group.long 0xec--0xef "AHB_SYS_DUMMY1 (at 0x800020ec) "
    line.long 0x0 "VALUE"
  tree.end
  tree "AHB_SYS_DUMMY2"
   group.long 0xf0--0xf3 "AHB_SYS_DUMMY2 (at 0x800020f0) "
    line.long 0x0 "VALUE"
  tree.end
 tree "SYS_FINE_TABLEn"
  tree "SYS_FINE_TABLE0"
   group.long 0xf4--0xf7 "SYS_FINE_TABLE0 (at 0x800020f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE1"
   group.long 0xf8--0xfb "SYS_FINE_TABLE1 (at 0x800020f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE2"
   group.long 0xfc--0xff "SYS_FINE_TABLE2 (at 0x800020fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE3"
   group.long 0x100--0x103 "SYS_FINE_TABLE3 (at 0x80002100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE4"
   group.long 0x104--0x107 "SYS_FINE_TABLE4 (at 0x80002104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE5"
   group.long 0x108--0x10b "SYS_FINE_TABLE5 (at 0x80002108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE6"
   group.long 0x10c--0x10f "SYS_FINE_TABLE6 (at 0x8000210c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_FINE_TABLE7"
   group.long 0x110--0x113 "SYS_FINE_TABLE7 (at 0x80002110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "SYS_COARSE_TABLEn"
  tree "SYS_COARSE_TABLE0"
   group.long 0x114--0x117 "SYS_COARSE_TABLE0 (at 0x80002114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE1"
   group.long 0x118--0x11b "SYS_COARSE_TABLE1 (at 0x80002118) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE2"
   group.long 0x11c--0x11f "SYS_COARSE_TABLE2 (at 0x8000211c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE3"
   group.long 0x120--0x123 "SYS_COARSE_TABLE3 (at 0x80002120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE4"
   group.long 0x124--0x127 "SYS_COARSE_TABLE4 (at 0x80002124) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE5"
   group.long 0x128--0x12b "SYS_COARSE_TABLE5 (at 0x80002128) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE6"
   group.long 0x12c--0x12f "SYS_COARSE_TABLE6 (at 0x8000212c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SYS_COARSE_TABLE7"
   group.long 0x130--0x133 "SYS_COARSE_TABLE7 (at 0x80002130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "APP_FINE_TABLEn"
  tree "APP_FINE_TABLE0"
   group.long 0x174--0x177 "APP_FINE_TABLE0 (at 0x80002174) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE1"
   group.long 0x178--0x17b "APP_FINE_TABLE1 (at 0x80002178) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE2"
   group.long 0x17c--0x17f "APP_FINE_TABLE2 (at 0x8000217c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE3"
   group.long 0x180--0x183 "APP_FINE_TABLE3 (at 0x80002180) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE4"
   group.long 0x184--0x187 "APP_FINE_TABLE4 (at 0x80002184) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE5"
   group.long 0x188--0x18b "APP_FINE_TABLE5 (at 0x80002188) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE6"
   group.long 0x18c--0x18f "APP_FINE_TABLE6 (at 0x8000218c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_FINE_TABLE7"
   group.long 0x190--0x193 "APP_FINE_TABLE7 (at 0x80002190) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "APP_COARSE_TABLEn"
  tree "APP_COARSE_TABLE0"
   group.long 0x194--0x197 "APP_COARSE_TABLE0 (at 0x80002194) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE1"
   group.long 0x198--0x19b "APP_COARSE_TABLE1 (at 0x80002198) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE2"
   group.long 0x19c--0x19f "APP_COARSE_TABLE2 (at 0x8000219c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE3"
   group.long 0x1a0--0x1a3 "APP_COARSE_TABLE3 (at 0x800021a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE4"
   group.long 0x1a4--0x1a7 "APP_COARSE_TABLE4 (at 0x800021a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE5"
   group.long 0x1a8--0x1ab "APP_COARSE_TABLE5 (at 0x800021a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE6"
   group.long 0x1ac--0x1af "APP_COARSE_TABLE6 (at 0x800021ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "APP_COARSE_TABLE7"
   group.long 0x1b0--0x1b3 "APP_COARSE_TABLE7 (at 0x800021b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   VALID                          = " "0 (EMPTY),1 (VALID) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MID                            = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
  tree "GT_SLOT_SIZE"
   group.long 0x1b8--0x1bb "GT_SLOT_SIZE (at 0x800021b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   APP_SLOT_SIZE                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SYS_SLOT_SIZE                  = "
  tree.end
tree.end

base ad:0x8002e000
tree "APP_MPU"
  tree "APP_MPU_ENABLE"
   group.long 0x0--0x3 "APP_MPU_ENABLE (at 0x8002e000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EN                             = " "0 (NOT_ENABLED),1 (ENABLED) "
  tree.end
  tree "APP_MPU_ERR_STATS"
   group.long 0x4--0x7 "APP_MPU_ERR_STATS (at 0x8002e004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   BUS_REQ_ADDR                   = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BUS_REQ_MID                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   BUS_REQ_SID                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BUS_REQ_TYPE                   = " "0,1 "
  tree.end
  tree "APP_MPU_DEF_PART_PERM0"
   group.long 0x8--0xb "APP_MPU_DEF_PART_PERM0 (at 0x8002e008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   ID_6                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ID_5                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ID_4                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID_3                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
 tree "APP_MPU_PART_START_ADDRa"
  tree "APP_MPU_PART_START_ADDR0"
   group.long 0x20--0x23 "APP_MPU_PART_START_ADDR0 (at 0x8002e020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_START_ADDR1"
   group.long 0x40--0x43 "APP_MPU_PART_START_ADDR1 (at 0x8002e040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_START_ADDR2"
   group.long 0x60--0x63 "APP_MPU_PART_START_ADDR2 (at 0x8002e060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_START_ADDR3"
   group.long 0x80--0x83 "APP_MPU_PART_START_ADDR3 (at 0x8002e080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
 tree.end
 tree "APP_MPU_PART_END_ADDRa"
  tree "APP_MPU_PART_END_ADDR0"
   group.long 0x24--0x27 "APP_MPU_PART_END_ADDR0 (at 0x8002e024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_END_ADDR1"
   group.long 0x44--0x47 "APP_MPU_PART_END_ADDR1 (at 0x8002e044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_END_ADDR2"
   group.long 0x64--0x67 "APP_MPU_PART_END_ADDR2 (at 0x8002e064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "APP_MPU_PART_END_ADDR3"
   group.long 0x84--0x87 "APP_MPU_PART_END_ADDR3 (at 0x8002e084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
 tree.end
 tree "APP_MPU_PART_PERM0a"
  tree "APP_MPU_PART_PERM00"
   group.long 0x28--0x2b "APP_MPU_PART_PERM00 (at 0x8002e028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   ID_6                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ID_5                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ID_4                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID_3                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "APP_MPU_PART_PERM01"
   group.long 0x48--0x4b "APP_MPU_PART_PERM01 (at 0x8002e048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   ID_6                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ID_5                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ID_4                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID_3                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "APP_MPU_PART_PERM02"
   group.long 0x68--0x6b "APP_MPU_PART_PERM02 (at 0x8002e068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   ID_6                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ID_5                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ID_4                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID_3                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "APP_MPU_PART_PERM03"
   group.long 0x88--0x8b "APP_MPU_PART_PERM03 (at 0x8002e088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   ID_6                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ID_5                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ID_4                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID_3                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
 tree.end
tree.end

base ad:0x80024000
tree "ARM9_MTI"
  tree "CHIP_ARM9_TEST_MEM_ADDR"
   group.long 0x0--0x3 "CHIP_ARM9_TEST_MEM_ADDR (at 0x80024000)   (shadowed - Use hwio_shadow_ptr->CHIP_ARM9_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DATA                           = "
  tree.end
  tree "CHIP_ARM9_TEST_MEM_WRITE"
   group.long 0x4--0x7 "CHIP_ARM9_TEST_MEM_WRITE (at 0x80024004)   (shadowed - Use hwio_shadow_ptr->CHIP_ARM9_TEST_MEM_WRITE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "CHIP_ARM9_TEST_MEM_SEL"
   group.long 0x8--0xb "CHIP_ARM9_TEST_MEM_SEL (at 0x80024008)   (shadowed - Use hwio_shadow_ptr->CHIP_ARM9_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MTI_MUX_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TST_EN_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DN_UP_N                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TST_SEL_ALL                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RAM_SEL                        = "
  tree.end
  tree "CHIP_ARM9_TEST_MEM_READ0"
   group.long 0xc--0xf "CHIP_ARM9_TEST_MEM_READ0 (at 0x8002400c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "CHIP_ARM9_TEST_MEM_WRITE_NON_INCR"
   group.long 0x10--0x13 "CHIP_ARM9_TEST_MEM_WRITE_NON_INCR (at 0x80024010)   (shadowed - Use hwio_shadow_ptr->CHIP_ARM9_TEST_MEM_WRITE_NON_INCR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "CHIP_ARM9_TEST_MEM_READ0_NON_INCR"
   group.long 0x14--0x17 "CHIP_ARM9_TEST_MEM_READ0_NON_INCR (at 0x80024014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "ARM9_11_MEM_ACC_CTRL"
   group.long 0x18--0x1b "ARM9_11_MEM_ACC_CTRL (at 0x80024018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SPARE                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x5--0x8 1 "  [ 8: 5]   ARM11_ACC_CNTLR                = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ARM9_SW_CNTLR_EN               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ARM9_ACC_CNTLR                 = "
  tree.end
tree.end

base ad:0x8001a000
tree "AUDIO"
  tree "AUX_CODEC_CTL"
   group.long 0x0--0x3 "AUX_CODEC_CTL (at 0x8001a000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   AUX_ONES_DETECT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   ADSP_CODEC_CTL_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   PCM_SYNC_LONG_OFFSET           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PCM_SYNC_SHORT_OFFSET          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PCM_SYNC_INVERT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   I2S_SAMPLE_CLK_SRC             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   I2S_SAMPLE_CLK_MODE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   I2S_RX_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   I2S_CLK_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AUX_PCM_MODE                   = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AUX_CODEC_MODE                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ONES_POLARITY                  = " "0,1 "
  tree.end
  tree "PCM_PATH_CTL"
   group.long 0x4--0x7 "PCM_PATH_CTL (at 0x8001a004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   ADSP_PATH_CTL                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ADSP_CTL_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   ADSP_RPCM_SEL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MDSP_RPCM_SEL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_RPCM_SEL                   = " "0,1 "
  tree.end
  tree "AUX_CODEC_CTL_OUT"
   group.long 0x8--0xb "AUX_CODEC_CTL_OUT (at 0x8001a008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   CODEC_INTF_CTL                 = "
  tree.end
  tree "WB_CODEC_TEST_CTL"
   group.long 0xc--0xf "WB_CODEC_TEST_CTL (at 0x8001a00c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   ADSP_WB_CTL_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WB_TEST_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CODEC_DEBUG_SEL                = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LOOP_SEL                       = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "WB_CODEC_FIFO_WR_REG"
   group.long 0x10--0x13 "WB_CODEC_FIFO_WR_REG (at 0x8001a010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CODEC_WR_DATA                  = "
  tree.end
  tree "WB_CODEC_FIFO_RD_REG"
   group.long 0x14--0x17 "WB_CODEC_FIFO_RD_REG (at 0x8001a014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CODEC_RD_DATA                  = "
  tree.end
  tree "WB_MISSED_ACKS_CNT"
   group.long 0x18--0x1b "WB_MISSED_ACKS_CNT (at 0x8001a018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RXF_RD_ACK_MISS_CNT            = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   CODEC_RD_ACK_MISS_CNT          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   CODEC_WR_ACK_MISS_CNT          = "
  tree.end
  tree "WB_CODEC_CMD_REG"
   group.long 0x1c--0x1f "WB_CODEC_CMD_REG (at 0x8001a01c)   (shadowed - Use hwio_shadow_ptr->WB_CODEC_CMD_REG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CLEAR_RXF_RD_ACK_CNT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLEAR_RD_ACK_CNT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLEAR_WR_ACK_CNT               = " "0,1 "
  tree.end
  tree "WB_CODEC_SEL_ADSP"
   group.long 0x20--0x23 "WB_CODEC_SEL_ADSP (at 0x8001a020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   WB_TEST_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   CODEC_DEBUG_SEL                = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   LOOP_SEL                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   TX_DMA32_RIGHT_MSW_SEL         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   TX_DMA32_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   RX_DMA32_RIGHT_MSW_SEL         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   RX_DMA32_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   RX_UP_BY_8_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   INVERTOUTPUT_RXDATA            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADD_INPUT_DCOFFSET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   FLIP_GET2XD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SEL_RAMSIS                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   TX_SYNC_VALUE                  = " "0 (SYNC_TO_RIGHT),1 (SYNC_TO_LEFT) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   SEL_SATURN_1B                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DITHER_BYPASS                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   DITHER_SHAPE_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SEL_SATURN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   DITHER_DLY_SEL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   FLIP_SEND2XD                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TX_MODE_SEL                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   RX_MODE_SEL                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RX_SYNC_VALUE                  = " "0 (SYNC_TO_RIGHT),1 (SYNC_TO_LEFT) "
  tree.end
tree.end

base ad:0x8001c000
tree "BPM"
  tree "BPM_CFG"
   group.long 0x0--0x3 "BPM_CFG (at 0x8001c000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   CGC_CLK_ENA                    = " "0 (NO_CLOCKS_RUNNING),1 (CYCLE_COUNTER),2 (reserved),3 (ALL_COUNTERS) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   TIMED_RUN_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   IRQ_ENA                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   MSTR_INCR_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   AHB_MASTER_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HREADY_REG_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SW_ACCUMULATE_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HW_ACCUMULATE_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HW_RUNSTOP_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   AUTO_RUN_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESTART_LOCK_DIS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CYC_CNTR_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PORT3_CNTRS_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PORT2_CNTRS_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PORT1_CNTRS_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_CNTRS_RESET              = " "0,1 "
  tree.end
  tree "BPM_CMD"
   group.long 0x4--0x7 "BPM_CMD (at 0x8001c004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RUN_STATUS                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SW_RESET                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACCUMULATE                     = " "0,1 "
  tree.end
  tree "BPM_MSTR_CFG"
   group.long 0x8--0xb "BPM_MSTR_CFG (at 0x8001c008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   AHB_ADDR                       = "
  tree.end
  tree "BPM_TIMER"
   group.long 0xc--0xf "BPM_TIMER (at 0x8001c00c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   MATCH_VAL                      = "
  tree.end
  tree "BPM_CYC_CFG"
   group.long 0x10--0x13 "BPM_CYC_CFG (at 0x8001c010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CYC_SAT_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT3_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PORT2_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT1_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_SAT_ENA                  = " "0,1 "
  tree.end
  tree "BPM_CYC_OUT"
   group.long 0x14--0x17 "BPM_CYC_OUT (at 0x8001c014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESULT                         = "
  tree.end
 tree "BPM_Cn_CFG0"
  tree "BPM_C0_CFG0"
   group.long 0x20--0x23 "BPM_C0_CFG0 (at 0x8001c020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   PORT_SEL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HOLD_MAX_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CYC_SAT_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT3_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PORT2_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT1_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_SAT_ENA                  = " "0,1 "
  tree.end
  tree "BPM_C1_CFG0"
   group.long 0x40--0x43 "BPM_C1_CFG0 (at 0x8001c040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   PORT_SEL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HOLD_MAX_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CYC_SAT_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT3_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PORT2_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT1_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_SAT_ENA                  = " "0,1 "
  tree.end
  tree "BPM_C2_CFG0"
   group.long 0x60--0x63 "BPM_C2_CFG0 (at 0x8001c060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   PORT_SEL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HOLD_MAX_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CYC_SAT_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT3_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PORT2_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT1_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_SAT_ENA                  = " "0,1 "
  tree.end
  tree "BPM_C3_CFG0"
   group.long 0x80--0x83 "BPM_C3_CFG0 (at 0x8001c080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   PORT_SEL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HOLD_MAX_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CYC_SAT_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT3_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PORT2_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT1_SAT_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PORT0_SAT_ENA                  = " "0,1 "
  tree.end
 tree.end
 tree "BPM_Cn_CFG1"
  tree "BPM_C0_CFG1"
   group.long 0x24--0x27 "BPM_C0_CFG1 (at 0x8001c024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   HWC_EN_3_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   HWC_EN_2_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   HWC_EN_1_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HWC_EN_0_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   HMASTLOCK_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   HWRITE_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HREADY_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HBURST_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   HTRANS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HSIZE_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HRESP_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HPROT_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HSEL_ENA                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HADDR_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MSTR_GNT_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARB_LAT_ENA                    = " "0,1 "
  tree.end
  tree "BPM_C1_CFG1"
   group.long 0x44--0x47 "BPM_C1_CFG1 (at 0x8001c044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   HWC_EN_3_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   HWC_EN_2_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   HWC_EN_1_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HWC_EN_0_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   HMASTLOCK_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   HWRITE_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HREADY_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HBURST_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   HTRANS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HSIZE_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HRESP_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HPROT_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HSEL_ENA                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HADDR_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MSTR_GNT_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARB_LAT_ENA                    = " "0,1 "
  tree.end
  tree "BPM_C2_CFG1"
   group.long 0x64--0x67 "BPM_C2_CFG1 (at 0x8001c064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   HWC_EN_3_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   HWC_EN_2_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   HWC_EN_1_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HWC_EN_0_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   HMASTLOCK_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   HWRITE_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HREADY_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HBURST_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   HTRANS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HSIZE_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HRESP_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HPROT_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HSEL_ENA                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HADDR_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MSTR_GNT_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARB_LAT_ENA                    = " "0,1 "
  tree.end
  tree "BPM_C3_CFG1"
   group.long 0x84--0x87 "BPM_C3_CFG1 (at 0x8001c084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   HWC_EN_3_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   HWC_EN_2_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   HWC_EN_1_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HWC_EN_0_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   HMASTLOCK_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   HWRITE_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HREADY_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HBURST_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   HTRANS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HSIZE_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HRESP_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HPROT_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HSEL_ENA                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HADDR_ENA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MSTR_GNT_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARB_LAT_ENA                    = " "0,1 "
  tree.end
 tree.end
 tree "BPM_Cn_CFG2"
  tree "BPM_C0_CFG2"
   group.long 0x28--0x2b "BPM_C0_CFG2 (at 0x8001c028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HWC_EN_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HMASTLOCK_VAL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HWRITE_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HREADY_VAL                     = " "0,1 "
  tree.end
  tree "BPM_C1_CFG2"
   group.long 0x48--0x4b "BPM_C1_CFG2 (at 0x8001c048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HWC_EN_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HMASTLOCK_VAL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HWRITE_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HREADY_VAL                     = " "0,1 "
  tree.end
  tree "BPM_C2_CFG2"
   group.long 0x68--0x6b "BPM_C2_CFG2 (at 0x8001c068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HWC_EN_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HMASTLOCK_VAL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HWRITE_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HREADY_VAL                     = " "0,1 "
  tree.end
  tree "BPM_C3_CFG2"
   group.long 0x88--0x8b "BPM_C3_CFG2 (at 0x8001c088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HWC_EN_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HMASTLOCK_VAL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   HWRITE_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HREADY_VAL                     = " "0,1 "
  tree.end
 tree.end
 tree "BPM_Cn_CFG3"
  tree "BPM_C0_CFG3"
   group.long 0x2c--0x2f "BPM_C0_CFG3 (at 0x8001c02c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HBURST_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   HBURST_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HBURST_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HTRANS_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HTRANS_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HTRANS_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HSIZE_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   HSIZE_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HSIZE_VAL                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HRESP_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   HRESP_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HRESP_VAL                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "BPM_C1_CFG3"
   group.long 0x4c--0x4f "BPM_C1_CFG3 (at 0x8001c04c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HBURST_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   HBURST_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HBURST_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HTRANS_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HTRANS_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HTRANS_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HSIZE_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   HSIZE_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HSIZE_VAL                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HRESP_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   HRESP_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HRESP_VAL                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "BPM_C2_CFG3"
   group.long 0x6c--0x6f "BPM_C2_CFG3 (at 0x8001c06c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HBURST_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   HBURST_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HBURST_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HTRANS_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HTRANS_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HTRANS_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HSIZE_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   HSIZE_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HSIZE_VAL                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HRESP_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   HRESP_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HRESP_VAL                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "BPM_C3_CFG3"
   group.long 0x8c--0x8f "BPM_C3_CFG3 (at 0x8001c08c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HBURST_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   HBURST_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HBURST_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HTRANS_MASK                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HTRANS_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HTRANS_VAL                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HSIZE_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   HSIZE_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HSIZE_VAL                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HRESP_MASK                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   HRESP_INV                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HRESP_VAL                      = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "BPM_Cn_CFG4"
  tree "BPM_C0_CFG4"
   group.long 0x30--0x33 "BPM_C0_CFG4 (at 0x8001c030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HPROT_MASK                     = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HPROT_INV                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HPROT_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   HSEL_MASK                      = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HSEL_VAL                       = " "0,1 "
  tree.end
  tree "BPM_C1_CFG4"
   group.long 0x50--0x53 "BPM_C1_CFG4 (at 0x8001c050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HPROT_MASK                     = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HPROT_INV                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HPROT_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   HSEL_MASK                      = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HSEL_VAL                       = " "0,1 "
  tree.end
  tree "BPM_C2_CFG4"
   group.long 0x70--0x73 "BPM_C2_CFG4 (at 0x8001c070) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HPROT_MASK                     = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HPROT_INV                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HPROT_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   HSEL_MASK                      = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HSEL_VAL                       = " "0,1 "
  tree.end
  tree "BPM_C3_CFG4"
   group.long 0x90--0x93 "BPM_C3_CFG4 (at 0x8001c090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HPROT_MASK                     = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   HPROT_INV                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HPROT_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   HSEL_MASK                      = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HSEL_VAL                       = " "0,1 "
  tree.end
 tree.end
 tree "BPM_Cn_CFG5"
  tree "BPM_C0_CFG5"
   group.long 0x34--0x37 "BPM_C0_CFG5 (at 0x8001c034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   HADDR_INV                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x8--0x1b 1 "  [27: 8]   HADDR_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   HADDR_MASK                     = "
  tree.end
  tree "BPM_C1_CFG5"
   group.long 0x54--0x57 "BPM_C1_CFG5 (at 0x8001c054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   HADDR_INV                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x8--0x1b 1 "  [27: 8]   HADDR_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   HADDR_MASK                     = "
  tree.end
  tree "BPM_C2_CFG5"
   group.long 0x74--0x77 "BPM_C2_CFG5 (at 0x8001c074) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   HADDR_INV                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x8--0x1b 1 "  [27: 8]   HADDR_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   HADDR_MASK                     = "
  tree.end
  tree "BPM_C3_CFG5"
   group.long 0x94--0x97 "BPM_C3_CFG5 (at 0x8001c094) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   HADDR_INV                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x8--0x1b 1 "  [27: 8]   HADDR_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   HADDR_MASK                     = "
  tree.end
 tree.end
 tree "BPM_Cn_CFG6"
  tree "BPM_C0_CFG6"
   group.long 0x38--0x3b "BPM_C0_CFG6 (at 0x8001c038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   ARB_LAT_MASK                   = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   ARB_LAT_VAL                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   MSTR_GNT_MASK                  = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MSTR_GNT_VAL                   = " "0,1 "
  tree.end
  tree "BPM_C1_CFG6"
   group.long 0x58--0x5b "BPM_C1_CFG6 (at 0x8001c058)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   ARB_LAT_MASK                   = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   ARB_LAT_VAL                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   MSTR_GNT_MASK                  = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MSTR_GNT_VAL                   = " "0,1 "
  tree.end
  tree "BPM_C2_CFG6"
   group.long 0x78--0x7b "BPM_C2_CFG6 (at 0x8001c078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   ARB_LAT_MASK                   = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   ARB_LAT_VAL                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   MSTR_GNT_MASK                  = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MSTR_GNT_VAL                   = " "0,1 "
  tree.end
  tree "BPM_C3_CFG6"
   group.long 0x98--0x9b "BPM_C3_CFG6 (at 0x8001c098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   ARB_LAT_MASK                   = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   ARB_LAT_VAL                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   MSTR_GNT_MASK                  = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MSTR_GNT_VAL                   = " "0,1 "
  tree.end
 tree.end
 tree "BPM_Cn_OUT"
  tree "BPM_C0_OUT"
   group.long 0x3c--0x3f "BPM_C0_OUT (at 0x8001c03c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESULT                         = "
  tree.end
  tree "BPM_C1_OUT"
   group.long 0x5c--0x5f "BPM_C1_OUT (at 0x8001c05c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESULT                         = "
  tree.end
  tree "BPM_C2_OUT"
   group.long 0x7c--0x7f "BPM_C2_OUT (at 0x8001c07c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESULT                         = "
  tree.end
  tree "BPM_C3_OUT"
   group.long 0x9c--0x9f "BPM_C3_OUT (at 0x8001c09c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESULT                         = "
  tree.end
 tree.end
  tree "BPM_DBG_CFG"
   group.long 0x220--0x223 "BPM_DBG_CFG (at 0x8001c220)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_1                          = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_0                          = "
  tree.end
tree.end
tree "CDMA"
base ad:0x90000400
tree "CDMA_RTC"
  tree "CDMA_RTC_SYNC"
   group.long 0x0--0x3 "CDMA_RTC_SYNC (at 0x90000400)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CDMA_RTC_SYNC                  = "
  tree.end
  tree "RTC_CNT_1X"
   group.long 0x4--0x7 "RTC_CNT_1X (at 0x90000404)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   RTC_CNT_1X                     = "
  tree.end
  tree "RTC_SLEEP"
   group.long 0x8--0xb "RTC_SLEEP (at 0x90000408)   (shadowed - Use hwio_shadow_ptr->RTC_SLEEP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   RTC_SLEEP                      = "
  tree.end
  tree "RTC_OFFSET"
   group.long 0xc--0xf "RTC_OFFSET (at 0x9000040c)   (shadowed - Use hwio_shadow_ptr->RTC_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   RTC_OFFSET                     = "
  tree.end
  tree "RTC_LOAD"
   group.long 0x10--0x13 "RTC_LOAD (at 0x90000410)   (shadowed - Use hwio_shadow_ptr->RTC_LOAD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RTC_LOAD                       = "
  tree.end
  tree "RTC_CTL"
   group.long 0x14--0x17 "RTC_CTL (at 0x90000414)   (shadowed - Use hwio_shadow_ptr->RTC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ROLLOVER_INT_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESET_HDR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RESET_1X                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_ADJUST                     = " "0,1 "
  tree.end
  tree "RTC_GP_COMPARE1"
   group.long 0x18--0x1b "RTC_GP_COMPARE1 (at 0x90000418)   (shadowed - Use hwio_shadow_ptr->RTC_GP_COMPARE1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   RTC_GP_COMPARE1                = "
  tree.end
  tree "RTC_GP_COMPARE2"
   group.long 0x1c--0x1f "RTC_GP_COMPARE2 (at 0x9000041c)   (shadowed - Use hwio_shadow_ptr->RTC_GP_COMPARE2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   RTC_GP_COMPARE2                = "
  tree.end
  tree "RTC_DIFF_1XHDR"
   group.long 0x20--0x23 "RTC_DIFF_1XHDR (at 0x90000420)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   RTC_DIFF                       = "
  tree.end
  tree "RTC_INT_ENABLE"
   group.long 0x24--0x27 "RTC_INT_ENABLE (at 0x90000424)   (shadowed - Use hwio_shadow_ptr->RTC_INT_ENABLE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PN_ROLLOVER_1X                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PN_ROLLOVER_HDR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RTC_CMP2                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_CMP1                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DEM_GP_CMP                     = " "0,1 "
  tree.end
  tree "RTC_INT_CLEAR"
   group.long 0x28--0x2b "RTC_INT_CLEAR (at 0x90000428)   (shadowed - Use hwio_shadow_ptr->RTC_INT_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PN_ROLLOVER_1X                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PN_ROLLOVER_HDR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RTC_CMP2                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_CMP1                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DEM_GP_CMP                     = " "0,1 "
  tree.end
  tree "RTC_INT_STATUS"
   group.long 0x2c--0x2f "RTC_INT_STATUS (at 0x9000042c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PN_ROLLOVER_1X                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PN_ROLLOVER_HDR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RTC_CMP2                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_CMP1                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DEM_GP_CMP                     = " "0,1 "
  tree.end
  tree "RTC_INT_SELECT"
   group.long 0x30--0x33 "RTC_INT_SELECT (at 0x90000430)   (shadowed - Use hwio_shadow_ptr->RTC_INT_SELECT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ROLLOVER_1X_SEL                = " "0,1 "
  tree.end
  tree "RTC_TTRANS_CTL_1XHDR"
   group.long 0x34--0x37 "RTC_TTRANS_CTL_1XHDR (at 0x90000434)   (shadowed - Use hwio_shadow_ptr->RTC_TTRANS_CTL_1XHDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TTRANS_EN_HDR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TTRANS_EN_1X                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IMMD_DUMP                      = " "0,1 "
  tree.end
  tree "RTC_DUMP_STATUS_1XHDR"
   group.long 0x38--0x3b "RTC_DUMP_STATUS_1XHDR (at 0x90000438) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DUMP_DONE                      = " "0,1 "
  tree.end
  tree "RTC_TTRANS_TRIG_1X"
   group.long 0x3c--0x3f "RTC_TTRANS_TRIG_1X (at 0x9000043c)   (shadowed - Use hwio_shadow_ptr->RTC_TTRANS_TRIG_1X to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TRIG_VAL                       = "
  tree.end
  tree "RTC_TTRANS_TRIG_HDR"
   group.long 0x40--0x43 "RTC_TTRANS_TRIG_HDR (at 0x90000440)   (shadowed - Use hwio_shadow_ptr->RTC_TTRANS_TRIG_HDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TRIG_VAL                       = "
  tree.end
  tree "RTC_DUMP_1X"
   group.long 0x44--0x47 "RTC_DUMP_1X (at 0x90000444)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DUMP_VAL                       = "
  tree.end
  tree "RTC_DUMP_HDR"
   group.long 0x48--0x4b "RTC_DUMP_HDR (at 0x90000448)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DUMP_VAL                       = "
  tree.end
tree.end

base ad:0x90000600
tree "CDMA_SAMPSRV"
 tree "CDMA_SAMPSRV_n_CTL"
  tree "CDMA_SAMPSRV_0_CTL"
   group.long 0x0--0x3 "CDMA_SAMPSRV_0_CTL (at 0x90000600) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   IMMED_START                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xe--0x18 1 "  [24:14]   STOP_TIME                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   START_RTC                      = "
  tree.end
  tree "CDMA_SAMPSRV_1_CTL"
   group.long 0x4--0x7 "CDMA_SAMPSRV_1_CTL (at 0x90000604) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   IMMED_START                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xe--0x18 1 "  [24:14]   STOP_TIME                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   START_RTC                      = "
  tree.end
 tree.end
 tree "CDMA_SAMPSRV_n_MODE"
  tree "CDMA_SAMPSRV_0_MODE"
   group.long 0x8--0xb "CDMA_SAMPSRV_0_MODE (at 0x90000608) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TESTBUS_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ANT_SEL                        = " "0 (ANTENNA0),1 (ANTENNA1) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SAMPLE_RXCH_SEL                = " "0 (1X),1 (HDR),2 (GPS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SAMPLE_ENA                     = " "0 (reserved),1 (reserved),2 (ALWAYS_ENABLED),3 (TIMED_CONTROL) "
  tree.end
  tree "CDMA_SAMPSRV_1_MODE"
   group.long 0xc--0xf "CDMA_SAMPSRV_1_MODE (at 0x9000060c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TESTBUS_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ANT_SEL                        = " "0 (ANTENNA0),1 (ANTENNA1) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SAMPLE_RXCH_SEL                = " "0 (1X),1 (HDR),2 (GPS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SAMPLE_ENA                     = " "0 (reserved),1 (reserved),2 (ALWAYS_ENABLED),3 (TIMED_CONTROL) "
  tree.end
 tree.end
  tree "CDMA_SAMPSRV_TEST_RAM_WE_CTL"
   group.long 0x10--0x13 "CDMA_SAMPSRV_TEST_RAM_WE_CTL (at 0x90000610) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DATA                           = " "0 (READ),1 (WRITE) "
  tree.end
  tree "CDMA_SAMPSRV_TEST_RAM_ADDR"
   group.long 0x14--0x17 "CDMA_SAMPSRV_TEST_RAM_ADDR (at 0x90000614) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   ANT_SEL                        = " "0 (ANTENNA_0),1 (ANTENNA_1) "
    textline ""
    hexmask.long.word 0x0 0x1--0xa 1 "  [10: 1]   RAM_ADDR                       = "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RAM_BANK                       = " "0 (LOW_ORDER_BANK),1 (HIGH_ORDER_BANK) "
  tree.end
  tree "CDMA_SAMPSRV_TEST_RAM_DATA"
   group.long 0x18--0x1b "CDMA_SAMPSRV_TEST_RAM_DATA (at 0x90000618) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree "CDMA_SAMPSRV_n_LATEST_RTC"
  tree "CDMA_SAMPSRV_0_LATEST_RTC"
   group.long 0x1c--0x1f "CDMA_SAMPSRV_0_LATEST_RTC (at 0x9000061c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   DATA                           = "
  tree.end
  tree "CDMA_SAMPSRV_1_LATEST_RTC"
   group.long 0x20--0x23 "CDMA_SAMPSRV_1_LATEST_RTC (at 0x90000620) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   DATA                           = "
  tree.end
 tree.end
  tree "CDMA_PNSRV_ROM_BIST_MODE"
   group.long 0x24--0x27 "CDMA_PNSRV_ROM_BIST_MODE (at 0x90000624) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE                           = " "0 (DISABLED),1 (ASCEND),2 (DESCEND),3 (ASCEND_SCRAM),4 (DESCEND_SCRAM),5 (reserved),6 (reserved),7 (1175) "
  tree.end
  tree "CDMA_PNSRV_ROM_BIST_STATUS"
   group.long 0x2c--0x2f "CDMA_PNSRV_ROM_BIST_STATUS (at 0x9000062c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   STATUS                         = " "0 (INACTIVE),1 (ACTIVE) "
  tree.end
  tree "CDMA_PNSRV_TEST_MODE"
   group.long 0x30--0x33 "CDMA_PNSRV_TEST_MODE (at 0x90000630) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                           = " "0 (DISABLED),1 (ENABLED),2 (ENABLED_PN_ROM_DATA_OUT),3 (reserved) "
  tree.end
  tree "CDMA_PNSRV_TEST_EXPORT_MISR"
   group.long 0x38--0x3b "CDMA_PNSRV_TEST_EXPORT_MISR (at 0x90000638) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXPORT                         = " "0,1 "
  tree.end
  tree "CDMA_PNSRV_TEST_MISR_CURR_VAL"
   group.long 0x3c--0x3f "CDMA_PNSRV_TEST_MISR_CURR_VAL (at 0x9000063c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "CDMA_SAMPSRV_CLK_DISABLE"
   group.long 0x40--0x43 "CDMA_SAMPSRV_CLK_DISABLE (at 0x90000640)   (shadowed - Use hwio_shadow_ptr->CDMA_SAMPSRV_CLK_DISABLE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_OFF                        = " "0,1 "
  tree.end
  tree "CDMA_SAMPSRV_CLK_STATUS"
   group.long 0x44--0x47 "CDMA_SAMPSRV_CLK_STATUS (at 0x90000644)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_IS_OFF                     = " "0,1 "
  tree.end
  tree "CDMA_SAMPSRV_CTL_SEL"
   group.long 0x48--0x4b "CDMA_SAMPSRV_CTL_SEL (at 0x90000648) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CTL_SEL                        = " "0 (ARM),1 (MDSP) "
  tree.end
tree.end

base ad:0x90001400
tree "CDMA_TX"
  tree "MOD_MODE"
   group.long 0x0--0x3 "MOD_MODE (at 0x90001400) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   DO_A                           = " "0 (HDR_REV0),1 (HDR_REVA) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   HDR                            = " "0 (1X),1 (HDR) "
  tree.end
 tree "I_PN_STATE_w"
  tree "I_PN_STATE_0"
   group.long 0x8--0xb "I_PN_STATE_0 (at 0x90001408)   (shadowed - Use hwio_shadow_ptr->I_PN_STATE_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "I_PN_STATE_1"
   group.long 0xc--0xf "I_PN_STATE_1 (at 0x9000140c)   (shadowed - Use hwio_shadow_ptr->I_PN_STATE_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree "Q_PN_STATE_w"
  tree "Q_PN_STATE_0"
   group.long 0x10--0x13 "Q_PN_STATE_0 (at 0x90001410)   (shadowed - Use hwio_shadow_ptr->Q_PN_STATE_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "Q_PN_STATE_1"
   group.long 0x14--0x17 "Q_PN_STATE_1 (at 0x90001414)   (shadowed - Use hwio_shadow_ptr->Q_PN_STATE_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
  tree "U_PN_STATE_0"
   group.long 0x18--0x1b "U_PN_STATE_0 (at 0x90001418)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_STATE_1"
   group.long 0x1c--0x1f "U_PN_STATE_1 (at 0x9000141c)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_STATE_2"
   group.long 0x20--0x23 "U_PN_STATE_2 (at 0x90001420)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_STATE_3"
   group.long 0x24--0x27 "U_PN_STATE_3 (at 0x90001424)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_STATE_4"
   group.long 0x28--0x2b "U_PN_STATE_4 (at 0x90001428)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_STATE_5"
   group.long 0x2c--0x2f "U_PN_STATE_5 (at 0x9000142c)   (shadowed - Use hwio_shadow_ptr->U_PN_STATE_5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BOZO                           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x2--0x6 1 "  [ 6: 2]   UNDEFINED_BITS6_2              = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   U_PN_STATE                     = " "0,1,2,3 "
  tree.end
 tree "U_PN_MASK_w"
  tree "U_PN_MASK_0"
   group.long 0x30--0x33 "U_PN_MASK_0 (at 0x90001430)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_MASK_1"
   group.long 0x34--0x37 "U_PN_MASK_1 (at 0x90001434)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_MASK_2"
   group.long 0x38--0x3b "U_PN_MASK_2 (at 0x90001438)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_MASK_3"
   group.long 0x3c--0x3f "U_PN_MASK_3 (at 0x9000143c)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_MASK_4"
   group.long 0x40--0x43 "U_PN_MASK_4 (at 0x90001440)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "U_PN_MASK_5"
   group.long 0x44--0x47 "U_PN_MASK_5 (at 0x90001444)   (shadowed - Use hwio_shadow_ptr->U_PN_MASK_5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
  tree "FRAME_OFF"
   group.long 0x48--0x4b "FRAME_OFF (at 0x90001448)   (shadowed - Use hwio_shadow_ptr->FRAME_OFF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   UNUSED_BIT6_2                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REV_OFF_20M                    = "
  tree.end
  tree "MOD_STMR_MODIFIER_0"
   group.long 0x4c--0x4f "MOD_STMR_MODIFIER_0 (at 0x9000144c)   (shadowed - Use hwio_shadow_ptr->MOD_STMR_MODIFIER_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_STMR_MODIFIER_1"
   group.long 0x50--0x53 "MOD_STMR_MODIFIER_1 (at 0x90001450)   (shadowed - Use hwio_shadow_ptr->MOD_STMR_MODIFIER_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                           = "
  tree.end
  tree "TX_PCG_INT_ENABLE"
   group.long 0x58--0x5b "TX_PCG_INT_ENABLE (at 0x90001458) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TX_PCG_INT_ENABLE              = "
  tree.end
  tree "TX_PCG_INT_STATUS"
   group.long 0x60--0x63 "TX_PCG_INT_STATUS (at 0x90001460)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TX_PCG_INT_STATUS              = "
  tree.end
  tree "MOD_TX_TIME_RD"
   group.long 0xec--0xef "MOD_TX_TIME_RD (at 0x900014ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   DATA                           = "
  tree.end
  tree "MOD_CH1_TIMING_CTL"
   group.long 0x64--0x67 "MOD_CH1_TIMING_CTL (at 0x90001464)   (shadowed - Use hwio_shadow_ptr->MOD_CH1_TIMING_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UNUSED_BIT2                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CH1_BEGIN_ENC_TIME             = " "0,1,2,3 "
  tree.end
  tree "MOD_CH2_TIMING_CTL"
   group.long 0x68--0x6b "MOD_CH2_TIMING_CTL (at 0x90001468)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_TIMING_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UNUSED_BIT2                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CH2_BEGIN_ENC_TIME             = " "0,1,2,3 "
  tree.end
  tree "MOD_CH3_TIMING_CTL"
   group.long 0x6c--0x6f "MOD_CH3_TIMING_CTL (at 0x9000146c)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_TIMING_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH3_PCG_CNT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CH3_BEGIN_ENC_TIME             = " "0,1,2,3 "
  tree.end
  tree "MOD_WCOVER_SEL"
   group.long 0x70--0x73 "MOD_WCOVER_SEL (at 0x90001470)   (shadowed - Use hwio_shadow_ptr->MOD_WCOVER_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   CH1_WALSHCOVER_SEL             = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CH2_WALSHCOVER_SEL             = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CH3_WALSHCOVER_SEL             = "
  tree.end
  tree "MOD_CH1_ENC_CTL"
   group.long 0x74--0x77 "MOD_CH1_ENC_CTL (at 0x90001474)   (shadowed - Use hwio_shadow_ptr->MOD_CH1_ENC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xd 1 "  [13: 9]   CH1_CRC_LEN                    = "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   CH1_CODE_RATE                  = " "0 (1_2),1 (1_3),2 (1_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CH1_RADIO_CFG                  = " "0 (reserved),1 (reserved),2 (reserved),3 (RC3),4 (RC4),5 (RC5),6 (RC6),7 (WL_32) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CH1_ENC_RATE                   = " "0 (9_6),1 (14_4) "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH1_FRAME_SIZE                 = " "0 (5_MS),1 (10_MS),2 (20_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH1_EN                         = " "0,1 "
  tree.end
  tree "MOD_CH1_CRC_POLY"
   group.long 0x78--0x7b "MOD_CH1_CRC_POLY (at 0x90001478)   (shadowed - Use hwio_shadow_ptr->MOD_CH1_CRC_POLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_CH1_PUNCT_PATN_1"
   group.long 0x7c--0x7f "MOD_CH1_PUNCT_PATN_1 (at 0x9000147c)   (shadowed - Use hwio_shadow_ptr->MOD_CH1_PUNCT_PATN_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BITS15_8             = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DCCH_PUNCT_PATTERN_23_16       = "
  tree.end
  tree "MOD_CH1_PUNCT_PATN_0"
   group.long 0x80--0x83 "MOD_CH1_PUNCT_PATN_0 (at 0x90001480)   (shadowed - Use hwio_shadow_ptr->MOD_CH1_PUNCT_PATN_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DCCH_PUNCT_PATTERN_15_0        = "
  tree.end
  tree "MOD_CH2_ENC_CTL_0"
   group.long 0x84--0x87 "MOD_CH2_ENC_CTL_0 (at 0x90001484)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_ENC_CTL_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   FCH_TX_TONE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   UNDEFINED_BITS14_13            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   FCH_CRC_LENGTH                 = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UNDEFINED_BIT7                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FCH_CODE_RATE                  = " "0 (1_2),1 (1_3),2 (1_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UNUSED_BIT4                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FCH_ENC_RATE                   = " "0 (1_8),1 (1_4),2 (1_2),3 (FULL) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   IS_95_C                        = " "0 (IS_95_A),1 (IS_95_C) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FCH_EN                         = " "0,1 "
  tree.end
  tree "MOD_CH2_ENC_CTL_1"
   group.long 0x88--0x8b "MOD_CH2_ENC_CTL_1 (at 0x90001488)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_ENC_CTL_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   CH2_RADIO_CFG                  = " "0 (reserved),1 (RC1),2 (RC_2),3 (RC3),4 (RC4),5 (reserved),6 (reserved),7 (WL_32) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CH2_FRAME_SIZE                 = " "0 (5_MS),1 (10_MS),2 (20_MS),3 (reserved) "
  tree.end
  tree "MOD_CH2_CRC_POLY"
   group.long 0x8c--0x8f "MOD_CH2_CRC_POLY (at 0x9000148c)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_CRC_POLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_CH2_PUNCT_PATN_1"
   group.long 0x90--0x93 "MOD_CH2_PUNCT_PATN_1 (at 0x90001490)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_PUNCT_PATN_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BITS15_8             = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FCH_PUNCPATTERN_23_16          = "
  tree.end
  tree "MOD_CH2_PUNCT_PATN_0"
   group.long 0x94--0x97 "MOD_CH2_PUNCT_PATN_0 (at 0x90001494)   (shadowed - Use hwio_shadow_ptr->MOD_CH2_PUNCT_PATN_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FCH_PUNCPATTERN_15_0           = "
  tree.end
  tree "MOD_CH3_ENC_CTL_0"
   group.long 0x98--0x9b "MOD_CH3_ENC_CTL_0 (at 0x90001498)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_ENC_CTL_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   UNDEFINED_BIT15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SCH_LTU_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   TURBO_ENCODE                   = " "0 (CONVOLUTIONAL_ENCODER),1 (TURBO_ENCODE) "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   SCH_CRC_LENGTH                 = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SCH_CODE_RATE                  = " "0 (1_2),1 (1_3),2 (1_4),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SCH_ENC_RATE                   = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SCH_EN                         = " "0,1 "
  tree.end
  tree "MOD_CH3_ENC_CTL_1"
   group.long 0x9c--0x9f "MOD_CH3_ENC_CTL_1 (at 0x9000149c)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_ENC_CTL_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   UNDEFINED_BITS15_14            = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   MULTIFRAME                     = " "0 (N_1),1 (N_2),2 (N_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   LOW_REPEAT                     = " "0 (M_1),1 (M_2),2 (M_4),3 (M_8),4 (M_16),5 (M_32),6 (M_6),7 (153_6_KBPS) "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UNUSED_BIT8                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CH3_INTLV_SIZE                 = " "0 (SCH_384),1 (S_EA_CC_REQCH_768),2 (S_EA_CCCH_1536),3 (S_EA_CCCH_3072),4 (SCH_6144),5 (SCH_12288),6 (reserved),7 (153_6_KBPS) "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   CH3_SEL                        = " "0 (DISABLED),1 (SCH),2 (CCCH),3 (EACH),4 (REQCH),5 (reserved),6 (reserved),7 (153_6_KBPS) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CH3_FRAME_SIZE                 = " "0 (5_MS),1 (10_MS),2 (20_MS),3 (reserved) "
  tree.end
  tree "MOD_CH3_CRC_POLY"
   group.long 0xa0--0xa3 "MOD_CH3_CRC_POLY (at 0x900014a0)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_CRC_POLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_CH3_PUNCT_PATN_1"
   group.long 0xa4--0xa7 "MOD_CH3_PUNCT_PATN_1 (at 0x900014a4)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_PUNCT_PATN_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BITS15_8             = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SCH_PUNCPATTERN_23_16          = "
  tree.end
  tree "MOD_CH3_PUNCT_PATN_0"
   group.long 0xa8--0xab "MOD_CH3_PUNCT_PATN_0 (at 0x900014a8)   (shadowed - Use hwio_shadow_ptr->MOD_CH3_PUNCT_PATN_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SCH_PUNCPATTERN_15_0           = "
  tree.end
  tree "MOD_SCH_LTU_CTL"
   group.long 0xac--0xaf "MOD_SCH_LTU_CTL (at 0x900014ac)   (shadowed - Use hwio_shadow_ptr->MOD_SCH_LTU_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SCH_LTU_SIZE                   = "
  tree.end
  tree "MOD_MISC_CTL"
   group.long 0xb0--0xb3 "MOD_MISC_CTL (at 0x900014b0)   (shadowed - Use hwio_shadow_ptr->MOD_MISC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   IS95A_MODE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   TRAFFIC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RESERVED_BITS13                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RETRANS_DIS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   FCH_EIGHTH_GATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PICH_GATING_RATE               = " "0 (1),1 (1_2),2 (1_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CDMA2000_PICH_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UNUSED_BIT7                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RESERVED_BITS6                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   IS95A_ACCESS_CH                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   UNUSED_BITS4_2                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PA_CTL                         = " "0 (LOW),1 (NORMAL_FUNCTION),2 (reserved),3 (reserved) "
  tree.end
  tree "MOD_ROTATOR_MAP"
   group.long 0xb4--0xb7 "MOD_ROTATOR_MAP (at 0x900014b4)   (shadowed - Use hwio_shadow_ptr->MOD_ROTATOR_MAP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   STATE11_MAP                    = " "0 (ANGLE_0),1 (ANGLE_90),2 (ANGLE_180),3 (ANGLE_270) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   STATE10_MAP                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   STATE01_MAP                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STATE00_MAP                    = " "0,1,2,3 "
  tree.end
  tree "MOD_WSYM_STATE"
   group.long 0xb8--0xbb "MOD_WSYM_STATE (at 0x900014b8)   (shadowed - Use hwio_shadow_ptr->MOD_WSYM_STATE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   WSYM_CLK_WCHIP                 = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WSYM_CLK_PN                    = " "0,1,2,3 "
  tree.end
  tree "TX_VERY_EARLY_FRAME_CTL"
   group.long 0xbc--0xbf "TX_VERY_EARLY_FRAME_CTL (at 0x900014bc)   (shadowed - Use hwio_shadow_ptr->TX_VERY_EARLY_FRAME_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x2--0xc 1 "  [12: 2]   VERY_EARLY_FRAME_ADV           = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VERY_EARLY_FRAME_PER           = " "0 (EVERY_20_MS),1 (EVERY_10_MS),2 (EVERY_5_MS),3 (EVERY_1_25_MS) "
  tree.end
  tree "TX_2_EARLY_PCG_CTL"
   group.long 0xc0--0xc3 "TX_2_EARLY_PCG_CTL (at 0x900014c0)   (shadowed - Use hwio_shadow_ptr->TX_2_EARLY_PCG_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x2--0xc 1 "  [12: 2]   EARLY_2_PCG_EN_ADV             = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EARLY_2_PCG_EN_PER             = " "0 (20_MS),1 (10_MS),2 (5_MS),3 (SLOT) "
  tree.end
  tree "MOD_PICH_PCBIT_DATA"
   group.long 0xc4--0xc7 "MOD_PICH_PCBIT_DATA (at 0x900014c4)   (shadowed - Use hwio_shadow_ptr->MOD_PICH_PCBIT_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_PICH_PCBIT_MASK"
   group.long 0xc8--0xcb "MOD_PICH_PCBIT_MASK (at 0x900014c8)   (shadowed - Use hwio_shadow_ptr->MOD_PICH_PCBIT_MASK to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "MOD_STATUS"
   group.long 0xcc--0xcf "MOD_STATUS (at 0x900014cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CH1_CH2_ENC_POS_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CH1_ENC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CH1_ENC_WR_ERROR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CH3_ENC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH3_ENC_WR_ERROR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CH2_ENC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH2_ENC_WR_ERROR               = " "0,1 "
  tree.end
  tree "MASK_DATA"
   group.long 0xd0--0xd3 "MASK_DATA (at 0x900014d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "PA_PUNCT_FRAME_DIS"
   group.long 0xd4--0xd7 "PA_PUNCT_FRAME_DIS (at 0x900014d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   TX_PUNCT_FRAME_ALIGN           = " "0 (DISABLE_20MS_FB),1 (DISABLE_10MS_FB),2 (DISABLE_5MS_FB),3 (DISABLE_1_25MS_FB),4 (DISABLE_IMMEDIATELY),5 (reserved),6 (reserved),7 (153_6_KBPS) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_PUNCT_FRAME_DIS             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   PA_PUNCT_FRAME_ALIGN           = " "0 (DISABLE_20MS_FB),1 (DISABLE_10MS_FB),2 (DISABLE_5MS_FB),3 (DISABLE_1_25MS_FB),4 (DISABLE_IMMEDIATELY),5 (reserved),6 (reserved),7 (153_6_KBPS) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_PUNCT_FRAME_DIS             = " "0,1 "
  tree.end
  tree "PA_WARMUP"
   group.long 0xd8--0xdb "PA_WARMUP (at 0x900014d8)   (shadowed - Use hwio_shadow_ptr->PA_WARMUP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "TX_WARMUP"
   group.long 0xdc--0xdf "TX_WARMUP (at 0x900014dc)   (shadowed - Use hwio_shadow_ptr->TX_WARMUP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "MOD_TEST_CTL"
   group.long 0xf0--0xf3 "MOD_TEST_CTL (at 0x900014f0)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PCH_GATE_5MS_LAT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   UNUSED_BITS12_10               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PA_STATE_TEST_DATA             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PA_STATE_TEST_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TX_SPECTRAL_INVERSION          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   UNUSED_BIT5                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_DATA_CTL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MASK_CTL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SET_IQ_HIGH                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UNUSED_BIT0                    = " "0,1 "
  tree.end
  tree "TX_I_CLK"
   group.long 0xf4--0xf7 "TX_I_CLK (at 0x900014f4)   (shadowed - Use hwio_shadow_ptr->TX_I_CLK to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "MOD_CLK_CTL"
   group.long 0xf8--0xfb "MOD_CLK_CTL (at 0x900014f8)   (shadowed - Use hwio_shadow_ptr->MOD_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_CLK_INVERT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_CLKS_DISABLE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UNDEFINED_BITS6_0              = "
  tree.end
  tree "TX_DATA_TEST"
   group.long 0xfc--0xff "TX_DATA_TEST (at 0x900014fc)   (shadowed - Use hwio_shadow_ptr->TX_DATA_TEST to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   TST_I_DAC_DATA                 = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TST_IQ_DATA                    = "
  tree.end
  tree "TX_Q_DATA_TEST"
   group.long 0x100--0x103 "TX_Q_DATA_TEST (at 0x90001500)   (shadowed - Use hwio_shadow_ptr->TX_Q_DATA_TEST to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   UNDEFINED_BITS15_10            = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   TST_Q_DAC_DATA                 = "
  tree.end
  tree "MOD_TEST_POINT_SEL"
   group.long 0x104--0x107 "MOD_TEST_POINT_SEL (at 0x90001504)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_POINT_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DATA                           = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "MOD_TEST_MODE"
   group.long 0x110--0x113 "MOD_TEST_MODE (at 0x90001510) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   TEST_STB_EN                    = " "0 (O_S),1 (TEST_STROBES) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MISR_IN_SEL                    = "
  tree.end
  tree "MOD_TEST_EXPORT_MISR"
   group.long 0x114--0x117 "MOD_TEST_EXPORT_MISR (at 0x90001514) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EXPORT_MISR                    = " "0 (BYPASS_MISR),1 (MISR_VALUE) "
  tree.end
  tree "MOD_TEST_MISR_EN"
   group.long 0x118--0x11b "MOD_TEST_MISR_EN (at 0x90001518)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MISR_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   MISR_EN                        = " "0 (DIS),1 (EN) "
  tree.end
  tree "MOD_TEST_MISR_CTL"
   group.long 0x11c--0x11f "MOD_TEST_MISR_CTL (at 0x9000151c)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MISR_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   TST_10M_OFF_SEL                = " "0 (OFFSET_10M),1 (0_OFFSET_10M) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TST_INT_SEL                    = " "0 (MOD_INT_OUT),1 (MOD_INTERNAL) "
  tree.end
  tree "MOD_TEST_MISR_DLY"
   group.long 0x120--0x123 "MOD_TEST_MISR_DLY (at 0x90001520)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MISR_DLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MISR_DLY                       = "
  tree.end
  tree "MOD_TEST_CURR_MISR_VAL"
   group.long 0x124--0x127 "MOD_TEST_CURR_MISR_VAL (at 0x90001524)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   DATA                           = "
  tree.end
  tree "MOD_PDCH_TIMING_CTL"
   group.long 0x150--0x153 "MOD_PDCH_TIMING_CTL (at 0x90001550) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xd "  [13:11]   PCG_POS                        = " "0 (1ST_PCG),1 (2ND_PCG),2 (3RD_PCG),3 (4TH_PCG),4 (5TH_PCG),5 (6TH_PCG),6 (7TH_PCG),7 (8TH_PCG) "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   CHIP_POS                       = "
  tree.end
  tree "MOD_PDCH_CTL"
   group.long 0x154--0x157 "MOD_PDCH_CTL (at 0x90001554) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PKG_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SUBPKG_ID                      = " "0 (SUB_PACKET0),1 (SUB_PACKET1),2 (SUB_PACKET2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EN                             = " "0 (PDCH_DISABLE),1 (PDCH_ENABLE) "
  tree.end
  tree "MOD_PDCCH_CTL"
   group.long 0x170--0x173 "MOD_PDCCH_CTL (at 0x90001570) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1--0x7 1 "  [ 7: 1]   PDCCH_INFO                     = "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EN                             = " "0 (PDCH_DISABLE),1 (PDCH_ENABLE) "
  tree.end
  tree "MOD_SPICH_CTL"
   group.long 0x174--0x177 "MOD_SPICH_CTL (at 0x90001574) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EN                             = " "0 (SPICH_DISABLE),1 (SPICH_ENABLE) "
  tree.end
  tree "MOD_VAR_GAIN_SHIFT_DLY"
   group.long 0x178--0x17b "MOD_VAR_GAIN_SHIFT_DLY (at 0x90001578) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MOD_VAR_GAIN_SHIFT_DLY         = "
  tree.end
  tree "REVMOD_PN_LONG_STATE_0"
   group.long 0x180--0x183 "REVMOD_PN_LONG_STATE_0 (at 0x90001580)   (shadowed - Use hwio_shadow_ptr->REVMOD_PN_LONG_STATE_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree "REVMOD_PN_I_LONG_MASK_w"
  tree "REVMOD_PN_I_LONG_MASK_0"
   group.long 0x18c--0x18f "REVMOD_PN_I_LONG_MASK_0 (at 0x9000158c)   (shadowed - Use hwio_shadow_ptr->REVMOD_PN_I_LONG_MASK_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "REVMOD_PN_I_LONG_MASK_1"
   group.long 0x190--0x193 "REVMOD_PN_I_LONG_MASK_1 (at 0x90001590)   (shadowed - Use hwio_shadow_ptr->REVMOD_PN_I_LONG_MASK_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "REVMOD_PN_I_LONG_MASK_2"
   group.long 0x194--0x197 "REVMOD_PN_I_LONG_MASK_2 (at 0x90001594)   (shadowed - Use hwio_shadow_ptr->REVMOD_PN_I_LONG_MASK_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "REVMOD_PN_Q_LONG_MASK_w"
  tree "REVMOD_PN_Q_LONG_MASK_0"
   group.long 0x198--0x19b "REVMOD_PN_Q_LONG_MASK_0 (at 0x90001598)   (shadowed - Use hwio_shadow_ptr->REVMOD_PN_Q_LONG_MASK_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "REVMOD_PN_Q_LONG_MASK_1"
   group.long 0x19c--0x19f "REVMOD_PN_Q_LONG_MASK_1 (at 0x9000159c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "REVMOD_PN_Q_LONG_MASK_2"
   group.long 0x1a0--0x1a3 "REVMOD_PN_Q_LONG_MASK_2 (at 0x900015a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
  tree "REVMOD_PN_CTL"
   group.long 0x1a4--0x1a7 "REVMOD_PN_CTL (at 0x900015a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   BOZO_MODE                      = " "0 (BOZO_MODE_IS_ENABLED),1 (BOZO_MODE_IS_DISABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PN_LONG_CODE_LOAD              = " "0 (DONE),1 (IN_PROGRESS) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PN_I_LONG_CODE_LOAD            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PN_Q_LONG_CODE_LOAD            = " "0,1 "
  tree.end
  tree "REVMOD_FRAME_OFFSET"
   group.long 0x1a8--0x1ab "REVMOD_FRAME_OFFSET (at 0x900015a8)   (shadowed - Use hwio_shadow_ptr->REVMOD_FRAME_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DATA                           = "
  tree.end
  tree "REVMOD_TIME_STAMP_CTL"
   group.long 0x1ac--0x1af "REVMOD_TIME_STAMP_CTL (at 0x900015ac)   (shadowed - Use hwio_shadow_ptr->REVMOD_TIME_STAMP_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "REVMOD_TIME_STAMP"
   group.long 0x1b0--0x1b3 "REVMOD_TIME_STAMP (at 0x900015b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xc 1 "  [12: 6]   FRAME_COUNT                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   UPPER_6_BIT_TIME_COUN          = "
  tree.end
  tree "REVMOD_TIME_STAMP2"
   group.long 0x1b4--0x1b7 "REVMOD_TIME_STAMP2 (at 0x900015b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   EVEN_SECOND_COUNT              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   ZEROS                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   LOWER_9_BIT_CHIP_COUNT         = "
  tree.end
  tree "REVMOD_FRM_CNT_OFFSET"
   group.long 0x1b8--0x1bb "REVMOD_FRM_CNT_OFFSET (at 0x900015b8)   (shadowed - Use hwio_shadow_ptr->REVMOD_FRM_CNT_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "REVMOD_FRM_CNT_OFFSET_CTL"
   group.long 0x1bc--0x1bf "REVMOD_FRM_CNT_OFFSET_CTL (at 0x900015bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "REVMOD_TX_TIME_RD"
   group.long 0x1c4--0x1c7 "REVMOD_TX_TIME_RD (at 0x900015c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x19 1 "  [25: 0]   DATA                           = "
  tree.end
  tree "REVMOD_FRAME_INT_OFFSET"
   group.long 0x1c8--0x1cb "REVMOD_FRAME_INT_OFFSET (at 0x900015c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   EN                             = " "0 (FRAME_INT),1 (4_SLOT_SUB_FRAME_INT) "
    textline ""
    hexmask.long.word 0x0 0x4--0x10 1 "  [16: 4]   CHIP                           = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLOT                           = "
  tree.end
  tree "REVMOD_ENC_RATE"
   group.long 0x1cc--0x1cf "REVMOD_ENC_RATE (at 0x900015cc)   (shadowed - Use hwio_shadow_ptr->REVMOD_ENC_RATE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RR_INDEX                       = "
  tree.end
  tree "REVMOD_EDI_CONTROL"
   group.long 0x1d0--0x1d3 "REVMOD_EDI_CONTROL (at 0x900015d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EDI_ABORT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   EDI_EOF                        = " "0 (NO_END_OF_FRAME),1 (END_OF_FRAME) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EDI_READY                      = " "0,1 "
  tree.end
  tree "REVMOD_TENC_CTL"
   group.long 0x1d4--0x1d7 "REVMOD_TENC_CTL (at 0x900015d4)   (shadowed - Use hwio_shadow_ptr->REVMOD_TENC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "REVMOD_TENC_STATUS"
   group.long 0x1d8--0x1db "REVMOD_TENC_STATUS (at 0x900015d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   ENC_WAIT_STATUS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TDM_EDO_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EDI_READY                      = " "0,1 "
  tree.end
  tree "REVMOD_INBUF_STATUS"
   group.long 0x1dc--0x1df "REVMOD_INBUF_STATUS (at 0x900015dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ENC_PROG                       = " "0 (NOT_WORKING),1 (IN_PROGRESS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENC_MUX                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INBUF_MUX                      = " "0,1,2,3 "
  tree.end
  tree "REVMOD_OUTBUF_STATUS"
   group.long 0x1e0--0x1e3 "REVMOD_OUTBUF_STATUS (at 0x900015e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RD_MUX                         = " "0,1 "
  tree.end
  tree "REVMOD_RRI_REQUEST"
   group.long 0x1e4--0x1e7 "REVMOD_RRI_REQUEST (at 0x900015e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ACCESS_PILOT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RRI_REQUEST                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "REVMOD_MOD_CTL"
   group.long 0x1e8--0x1eb "REVMOD_MOD_CTL (at 0x900015e8)   (shadowed - Use hwio_shadow_ptr->REVMOD_MOD_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IQ_MOD_CTL                     = " "0,1 "
  tree.end
  tree "REVMOD_ENC_MODE"
   group.long 0x1ec--0x1ef "REVMOD_ENC_MODE (at 0x900015ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   UNUSED_BITS4_3                 = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CHN_INT_OFF                    = " "0 (CHANNEL_INTERLEAVER_IS_ON),1 (CHANNEL_INTERLEAVER_IS_OFF) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   UNUSED_BITS1_0                 = " "0,1,2,3 "
  tree.end
  tree "REVMOD_PA_CTL"
   group.long 0x1f0--0x1f3 "REVMOD_PA_CTL (at 0x900015f0)   (shadowed - Use hwio_shadow_ptr->REVMOD_PA_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   TX_WARMUP_EN                   = " "0 (TX_WARMUP_OFF),1 (TX_WARMUP_ON) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   PA_WARMUP_EN                   = " "0 (PA_WARMUP_OFF),1 (PA_WARMUP_ON) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   UNUSED_BIT6                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   TX_PUNC_CTL                    = " "0 (TX_PUNCT_LOW),1 (TX_PUNCT_HIGH) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DRC_DISABLE                    = " "0 (DRC_ENABLE),1 (DRC_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   PA_PUNC_CTL                    = " "0 (PA_PUNCT_LOW),1 (PA_PUNCT_HIGH) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   MOD_MASK_CTL                   = " "0 (IQ_MASK_OFF),1 (IQ_MASK_ON) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RRI_DISABLE                    = " "0 (RRI_ON),1 (RRI_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MDSP_CONTROL_EN                = " "0,1 "
  tree.end
  tree "REVMOD_PA_WARMUP"
   group.long 0x1f4--0x1f7 "REVMOD_PA_WARMUP (at 0x900015f4)   (shadowed - Use hwio_shadow_ptr->REVMOD_PA_WARMUP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DATA                           = "
  tree.end
  tree "REVMOD_TX_WARMUP"
   group.long 0x1f8--0x1fb "REVMOD_TX_WARMUP (at 0x900015f8)   (shadowed - Use hwio_shadow_ptr->REVMOD_TX_WARMUP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DATA                           = "
  tree.end
  tree "TX_AGC_CTL"
   group.long 0x220--0x223 "TX_AGC_CTL (at 0x90001620)   (shadowed - Use hwio_shadow_ptr->TX_AGC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TX_GAIN_ADJ_STEP_SIZE          = " "0 (1_DB),1 (0_5_DB),2 (0_25_DB),3 (reserved) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   LINEARIZER_RANGE_SEL           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RATCHET_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PA_R_POLARITY                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PA_R_OVERRIDE_N                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PA_R_WR                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TX_GAIN_BLIP_DELAY             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MASK_DELAY                     = " "0 (DELAY_OF_1_SLOT),1 (DELAY_OF_2_SLOTS),2 (DELAY_OF_3_SLOTS),3 (DELAY_OF_4_SLOTS),4 (DELAY_OF_5_SLOTS),5 (DELAY_OF_6_SLOTS),6 (DELAY_OF_7_SLOTS),7 (DELAY_OF_8_SLOTS) "
  tree.end
  tree "TX_AGC_CTL2"
   group.long 0x224--0x227 "TX_AGC_CTL2 (at 0x90001624)   (shadowed - Use hwio_shadow_ptr->TX_AGC_CTL2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TEMPORAL_HYST                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TX_MSM3000_MODE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   TX_MSM3100_MODE                = " "0 (DEFAULT),1 (MSM3100_MODE) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   FREEZE_PA_STATE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PWR_CTL_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TX_OPEN_LOOP_OVERRIDE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   REVERSED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_R_MAP_EN                    = " "0,1 "
  tree.end
  tree "AGC_TEST_CTL"
   group.long 0x22c--0x22f "AGC_TEST_CTL (at 0x9000162c)   (shadowed - Use hwio_shadow_ptr->AGC_TEST_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PA_STATE_WR                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PA_STATE_OVERRIDE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UNUSED_BIT0                    = " "0,1 "
  tree.end
  tree "AGC_TX_MASK_DATA_SEL"
   group.long 0x230--0x233 "AGC_TX_MASK_DATA_SEL (at 0x90001630)   (shadowed - Use hwio_shadow_ptr->AGC_TX_MASK_DATA_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "AGC_TX_RCCCH_FRAME_DELAY"
   group.long 0x234--0x237 "AGC_TX_RCCCH_FRAME_DELAY (at 0x90001634)   (shadowed - Use hwio_shadow_ptr->AGC_TX_RCCCH_FRAME_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "PA_R_MAP"
   group.long 0x238--0x23b "PA_R_MAP (at 0x90001638)   (shadowed - Use hwio_shadow_ptr->PA_R_MAP to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R_TIMER"
   group.long 0x23c--0x23f "PA_R_TIMER (at 0x9000163c)   (shadowed - Use hwio_shadow_ptr->PA_R_TIMER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R1_FALL"
   group.long 0x240--0x243 "PA_R1_FALL (at 0x90001640)   (shadowed - Use hwio_shadow_ptr->PA_R1_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R1_RISE"
   group.long 0x244--0x247 "PA_R1_RISE (at 0x90001644)   (shadowed - Use hwio_shadow_ptr->PA_R1_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R2_FALL"
   group.long 0x248--0x24b "PA_R2_FALL (at 0x90001648)   (shadowed - Use hwio_shadow_ptr->PA_R2_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R2_RISE"
   group.long 0x24c--0x24f "PA_R2_RISE (at 0x9000164c)   (shadowed - Use hwio_shadow_ptr->PA_R2_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R3_FALL"
   group.long 0x250--0x253 "PA_R3_FALL (at 0x90001650)   (shadowed - Use hwio_shadow_ptr->PA_R3_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "PA_R3_RISE"
   group.long 0x254--0x257 "PA_R3_RISE (at 0x90001654)   (shadowed - Use hwio_shadow_ptr->PA_R3_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree "PA_Sw_OFFSET"
  tree "PA_S0_OFFSET"
   group.long 0x258--0x25b "PA_S0_OFFSET (at 0x90001658)   (shadowed - Use hwio_shadow_ptr->PA_S0_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "PA_S1_OFFSET"
   group.long 0x25c--0x25f "PA_S1_OFFSET (at 0x9000165c)   (shadowed - Use hwio_shadow_ptr->PA_S1_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "PA_S2_OFFSET"
   group.long 0x260--0x263 "PA_S2_OFFSET (at 0x90001660)   (shadowed - Use hwio_shadow_ptr->PA_S2_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "PA_S3_OFFSET"
   group.long 0x264--0x267 "PA_S3_OFFSET (at 0x90001664)   (shadowed - Use hwio_shadow_ptr->PA_S3_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
  tree "PA_WARMUP_TIMER"
   group.long 0x268--0x26b "PA_WARMUP_TIMER (at 0x90001668)   (shadowed - Use hwio_shadow_ptr->PA_WARMUP_TIMER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PA_BYPASS_EN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PA_WARMUPTIMER                 = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "RAS_RAM_DATA"
   group.long 0x270--0x273 "RAS_RAM_DATA (at 0x90001670)   (shadowed - Use hwio_shadow_ptr->RAS_RAM_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SUBPCG_PA_WARMUP_DELAY"
   group.long 0x274--0x277 "SUBPCG_PA_WARMUP_DELAY (at 0x90001674)   (shadowed - Use hwio_shadow_ptr->SUBPCG_PA_WARMUP_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DATA                           = "
  tree.end
  tree "TX_ALIGN_DELAY"
   group.long 0x278--0x27b "TX_ALIGN_DELAY (at 0x90001678)   (shadowed - Use hwio_shadow_ptr->TX_ALIGN_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "TX_ATTEN_LIMIT_WR"
   group.long 0x27c--0x27f "TX_ATTEN_LIMIT_WR (at 0x9000167c)   (shadowed - Use hwio_shadow_ptr->TX_ATTEN_LIMIT_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   ATTEN_RATCHET_MODE             = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   TX_ATTEN_LIMIT                 = "
  tree.end
  tree "TX_GAIN_ADJ_WR"
   group.long 0x280--0x283 "TX_GAIN_ADJ_WR (at 0x90001680)   (shadowed - Use hwio_shadow_ptr->TX_GAIN_ADJ_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DATA                           = "
  tree.end
  tree "TX_GAIN_LIMIT_WR"
   group.long 0x284--0x287 "TX_GAIN_LIMIT_WR (at 0x90001684)   (shadowed - Use hwio_shadow_ptr->TX_GAIN_LIMIT_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "TX_OPEN_LOOP_WR"
   group.long 0x28c--0x28f "TX_OPEN_LOOP_WR (at 0x9000168c)   (shadowed - Use hwio_shadow_ptr->TX_OPEN_LOOP_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "TX_PDM_DELAY_VAL"
   group.long 0x290--0x293 "TX_PDM_DELAY_VAL (at 0x90001690)   (shadowed - Use hwio_shadow_ptr->TX_PDM_DELAY_VAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "VERY_EARLY_FRAME_DELAY_REG"
   group.long 0x298--0x29b "VERY_EARLY_FRAME_DELAY_REG (at 0x90001698)   (shadowed - Use hwio_shadow_ptr->VERY_EARLY_FRAME_DELAY_REG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "TX_AGC_TEST_POINT_SEL"
   group.long 0x29c--0x29f "TX_AGC_TEST_POINT_SEL (at 0x9000169c)   (shadowed - Use hwio_shadow_ptr->TX_AGC_TEST_POINT_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DATA                           = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "TX_PA_RD"
   group.long 0x2a4--0x2a7 "TX_PA_RD (at 0x900016a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   LOAD_LINEARIZER                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PA_R1_RD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_R0_RD                       = " "0,1 "
  tree.end
  tree "RATCHET_BIT_DIS"
   group.long 0x2a8--0x2ab "RATCHET_BIT_DIS (at 0x900016a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RATCHET_BIT_DOWN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RATCHET_BIT_UP                 = " "0,1 "
  tree.end
  tree "TX_AGC_ADJ_RD"
   group.long 0x2ac--0x2af "TX_AGC_ADJ_RD (at 0x900016ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DATA                           = "
  tree.end
  tree "TX_GAIN_ADJ_RD"
   group.long 0x2b0--0x2b3 "TX_GAIN_ADJ_RD (at 0x900016b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DATA                           = "
  tree.end
  tree "TX_GAIN_CTL_RD"
   group.long 0x2b4--0x2b7 "TX_GAIN_CTL_RD (at 0x900016b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "TX_OPEN_LOOP_RD"
   group.long 0x2b8--0x2bb "TX_OPEN_LOOP_RD (at 0x900016b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "MOD_PA_ON_CTL"
   group.long 0x2c0--0x2c3 "MOD_PA_ON_CTL (at 0x900016c0)   (shadowed - Use hwio_shadow_ptr->MOD_PA_ON_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PA_RANGE_SEL                   = " "0 (USE_THE_SIGNALS_FROM_HARDWARE),1 (USE_THE_SIGNALS_FROM_MDSP_OR_SOFTWARE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   TX_PUNCT_SEL                   = " "0 (USE_THE_SIGNAL_FROM_HARDWARE),1 (USE_THE_SIGNAL_FROM_MDSP_OR_SOFTWARE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   PA_PUNCT_SEL                   = " "0 (USE_THE_SIGNAL_FROM_HARDWARE),1 (USE_THE_SIGNAL_FROM_MDSP_OR_SOFTWARE) "
  tree.end
  tree "MOD_TX_AGC_ADJ_CTL"
   group.long 0x2c8--0x2cb "MOD_TX_AGC_ADJ_CTL (at 0x900016c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_AGC_EN_OVERRIDE             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TX_AGC_ADJ_SEL                 = " "0 (HW_SOURCE),1 (SW_SOURCE),2 (FW_SOURCE),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TX_AGC_ADJ_POLARITY            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_AGC_ADJ_OE                  = " "0,1 "
  tree.end
  tree "MOD_TX_AGC_ADJ"
   group.long 0x2cc--0x2cf "MOD_TX_AGC_ADJ (at 0x900016cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   TX_AGC_ADJ_VAL                 = "
  tree.end
  tree "MOD_TX_AGC_ODRIVE_DLY"
   group.long 0x2d0--0x2d3 "MOD_TX_AGC_ODRIVE_DLY (at 0x900016d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TX_AGC_ODRIVE_DLY              = "
  tree.end
  tree "MOD_HW_CLK_CTL"
   group.long 0x2d4--0x2d7 "MOD_HW_CLK_CTL (at 0x900016d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MOD_CX32_HW_LCG_ENA            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MOD_PDM_HW_LCG_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MOD_CX16_HW_LCG_ENA            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_CX8_HW_LCG_ENA             = " "0,1 "
  tree.end
  tree "MOD_MICRO_CLK_CTL"
   group.long 0x2d8--0x2db "MOD_MICRO_CLK_CTL (at 0x900016d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MOD_CX32_CLK_OVERRIDE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MOD_PDM_CLK_OVERRIDE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MOD_CX16_CLK_OVERRIDE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_CX8_CLK_OVERRIDE           = " "0,1 "
  tree.end
  tree "MOD_CLK_STATUS"
   group.long 0x2dc--0x2df "MOD_CLK_STATUS (at 0x900016dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MOD_CX32_CLK_IS_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MOD_PDM_CLK_IS_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MOD_CX16_CLK_IS_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_CX8_CLK_IS_OFF             = " "0,1 "
  tree.end
  tree "MOD_TX_SLOT_INT_STATUS"
   group.long 0x2e0--0x2e3 "MOD_TX_SLOT_INT_STATUS (at 0x900016e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PER_SLOT_INT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_TX_1_25_MS_INT             = " "0,1 "
  tree.end
  tree "MOD_TX_SLOT_INT_EN"
   group.long 0x2e8--0x2eb "MOD_TX_SLOT_INT_EN (at 0x900016e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PER_SLOT_INT_CLR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_TX_1_25_MS_INT_CLR         = " "0,1 "
  tree.end
  tree "MOD_TX_FR_INT_STATUS"
   group.long 0x2ec--0x2ef "MOD_TX_FR_INT_STATUS (at 0x900016ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FRAME_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_TX_FR_INT                  = " "0,1 "
  tree.end
  tree "MOD_TX_FR_INT_EN"
   group.long 0x2f4--0x2f7 "MOD_TX_FR_INT_EN (at 0x900016f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FRAME_INT_CLR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MOD_TX_FR_INT_CLR              = " "0,1 "
  tree.end
  tree "MOD_TXCX8_SPARE_READ_REG_0"
   group.long 0x300--0x303 "MOD_TXCX8_SPARE_READ_REG_0 (at 0x90001700) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "MOD_TXCX8_SPARE_READ_REG_1"
   group.long 0x304--0x307 "MOD_TXCX8_SPARE_READ_REG_1 (at 0x90001704) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "MOD_TXCX8_SPARE_READ_REG_2"
   group.long 0x308--0x30b "MOD_TXCX8_SPARE_READ_REG_2 (at 0x90001708) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "MOD_TXCX8_SPARE_READ_REG_3"
   group.long 0x30c--0x30f "MOD_TXCX8_SPARE_READ_REG_3 (at 0x9000170c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
tree.end
tree.end

base ad:0x80008000
tree "CHIP_BASE_BASE"
  tree "NAND_FLASH_CMD"
   group.long 0x0--0x3 "NAND_FLASH_CMD (at 0x80008000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x13--0x1f 1 "  [31:19]   RESERVED_BITS31_19             = "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   ONE_NAND_INTR_STATUS           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   ONE_NAND_HOST_CFG              = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x7--0x10 1 "  [16: 7]   AUTO_DETECT_DATA_XFR_SIZE      = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_DETECT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_PAGE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   PAGE_ACC                       = " "0 (NON_PAGE_ACCESS_COMMAND),1 (PAGE_ACCESS_COMMAND) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OP_CMD                         = "
  tree.end
  tree "NAND_ADDR0"
   group.long 0x4--0x7 "NAND_ADDR0 (at 0x80008004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR0                      = "
  tree.end
  tree "NAND_ADDR1"
   group.long 0x8--0xb "NAND_ADDR1 (at 0x80008008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR1                      = "
  tree.end
  tree "NAND_FLASH_CHIP_SELECT"
   group.long 0xc--0xf "NAND_FLASH_CHIP_SELECT (at 0x8000800c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x4--0x1f 1 "  [31: 4]   RESERVED_BITS31_4              = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   ONE_NAND_EN                    = " "0 (DISABLE_SUPPORT_FOR_ONENAND),1 (ENABLE_SUPPORT_FOR_ONENAND) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DM_EN                          = " "0 (DISABLE_DATA_MOVER_INTERFACE),1 (ENABLE_DATA_MOVER_INTERFACE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   BREAK_XFRS                     = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   NAND_DEV_SEL                   = " "0 (CS0_IS_SELECT),1 (CS1_IS_SELECTED) "
  tree.end
  tree "NANDC_EXEC_CMD"
   group.long 0x10--0x13 "NANDC_EXEC_CMD (at 0x80008010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS31_1              = "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EXEC_CMD                       = " "0 (reserved),1 (EXECUTE_THE_COMMAND) "
  tree.end
  tree "NAND_FLASH_STATUS"
   group.long 0x14--0x17 "NAND_FLASH_STATUS (at 0x80008014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DEV_STATUS                     = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   CODEWORD_CNTR                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   2KBYTE_DEVICE                  = " "0 (NOT_A_2K_BYTE_PAGE_DEVICE),1 (2K_BYTE_PAGE_DEVICE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   512BYTE_DEVICE                 = " "0 (reserved),1 (512_BYTE_PAGE_DEVICE) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   AUTO_DETECT_DONE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   MPU_ERROR                      = " "0 (NO_ERROR),1 (MPU_ERROR_FOR_THE_ACCESS) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   PROG_ERASE_OP_RESULT           = " "0 (NOT_SUCCESSFUL),1 (SUCCESSFUL) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RESERVED_BIT6                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   READY_BSY_N                    = " "0 (EXTERNAL_FLASH_IS_BUSY),1 (EXTERNAL_FLASH_IS_READY) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   OP_ERR                         = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OPER_STATUS                    = "
  tree.end
  tree "NANDC_BUFFER_STATUS"
   group.long 0x18--0x1b "NANDC_BUFFER_STATUS (at 0x80008018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   BAD_BLOCK_STATUS               = "
    textline ""
    hexmask.long.word 0x0 0x4--0xf 1 "  [15: 4]   RESERVED15_4                   = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UNCORRECTABLE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NUM_ERRORS                     = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree "NAND_DEVn_CFG0"
  tree "NAND_DEV0_CFG0"
   group.long 0x20--0x23 "NAND_DEV0_CFG0 (at 0x80008020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   SET_RD_MODE_AFTER_STATUS       = " "0 (DO_NOT_SEND),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x1e "  [   30]   STATUS_BFR_READ                = " "0 (DO_NOT_READ_STATUS),1 (READ_STATUS_BEFORE_DATA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1d "  [29:27]   NUM_ADDR_CYCLES                = " "0 (NO_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (PROGRAM_PAGE_WITH_ECC) "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1a 1 "  [26:23]   SPARE_SIZE_BYTES               = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x16 1 "  [22:19]   ECC_PARITY_SIZE_BYTES          = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   UD_SIZE_BYTES                  = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   CW_PER_PAGE                    = " "0 (1_CODEWORD_PER_PAGE),1 (2_CODEWORDS_PER_PAGE),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   ROW_ADDR_CYCLES                = " "0 (NO_ROW_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   COL_ADDR_CYCLES                = " "0 (NO_COLUMN_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
  tree.end
  tree "NAND_DEV1_CFG0"
   group.long 0x30--0x33 "NAND_DEV1_CFG0 (at 0x80008030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   SET_RD_MODE_AFTER_STATUS       = " "0 (DO_NOT_SEND),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x1e "  [   30]   STATUS_BFR_READ                = " "0 (DO_NOT_READ_STATUS),1 (READ_STATUS_BEFORE_DATA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1d "  [29:27]   NUM_ADDR_CYCLES                = " "0 (NO_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (PROGRAM_PAGE_WITH_ECC) "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1a 1 "  [26:23]   SPARE_SIZE_BYTES               = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x16 1 "  [22:19]   ECC_PARITY_SIZE_BYTES          = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   UD_SIZE_BYTES                  = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   CW_PER_PAGE                    = " "0 (1_CODEWORD_PER_PAGE),1 (2_CODEWORDS_PER_PAGE),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   ROW_ADDR_CYCLES                = " "0 (NO_ROW_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   COL_ADDR_CYCLES                = " "0 (NO_COLUMN_ADDRESS_CYCLES),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_CODEWORDS_PER_PAGE) "
  tree.end
 tree.end
 tree "NAND_DEVn_CFG1"
  tree "NAND_DEV0_CFG1"
   group.long 0x24--0x27 "NAND_DEV0_CFG1 (at 0x80008024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   RESERVED_BITS31_25             = "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   ECC_DECODER_CGC_EN             = " "0 (DECODER_CLOCK_GATING_DISABLE_FREE_RUNNING_CLOCK),1 (DECODER_CLOCK_GATING_ENABLE) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   ECC_ENCODER_CGC_EN             = " "0 (ENCODER_CLOCK_GATING_DISABLE_FREE_RUNNING_CLOCK),1 (ENCODER_CLOCK_GATING_ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0x11--0x16 1 "  [22:17]   WR_RD_BSY_GAP                  = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   BAD_BLOCK_IN_SPARE_AREA        = " "0 (IN_USER_DATA_AREA),1 (IN_SPARE_AREA) "
    textline ""
    hexmask.long.word 0x0 0x6--0xf 1 "  [15: 6]   BAD_BLOCK_BYTE_NUM             = "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   CS_ACTIVE_BSY                  = " "0 (ALLOW_CS_DE_ASSERTION),1 (ASSERT_CS_DURING_BUSY) "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   NAND_RECOVERY_CYCLES           = " "0 (1_RECOVERY_CYCLE),1 (2_RECOVERY_CYCLES),2 (3_RECOVERY_CYCLES),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_RECOVERY_CYCLES) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   WIDE_FLASH                     = " "0 (8_BIT_DATA_BUS),1 (16_BIT_DATA_BUS) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ECC_DISABLE                    = " "0 (ECC_ENABLED),1 (ECC_DISABLED) "
  tree.end
  tree "NAND_DEV1_CFG1"
   group.long 0x34--0x37 "NAND_DEV1_CFG1 (at 0x80008034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   RESERVED_BITS31_25             = "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   ECC_DECODER_CGC_EN             = " "0 (DECODER_CLOCK_GATING_DISABLE_FREE_RUNNING_CLOCK),1 (DECODER_CLOCK_GATING_ENABLE) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   ECC_ENCODER_CGC_EN             = " "0 (ENCODER_CLOCK_GATING_DISABLE_FREE_RUNNING_CLOCK),1 (ENCODER_CLOCK_GATING_ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0x11--0x16 1 "  [22:17]   WR_RD_BSY_GAP                  = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   BAD_BLOCK_IN_SPARE_AREA        = " "0 (IN_USER_DATA_AREA),1 (IN_SPARE_AREA) "
    textline ""
    hexmask.long.word 0x0 0x6--0xf 1 "  [15: 6]   BAD_BLOCK_BYTE_NUM             = "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   CS_ACTIVE_BSY                  = " "0 (ALLOW_CS_DE_ASSERTION),1 (ASSERT_CS_DURING_BUSY) "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   NAND_RECOVERY_CYCLES           = " "0 (1_RECOVERY_CYCLE),1 (2_RECOVERY_CYCLES),2 (3_RECOVERY_CYCLES),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (8_RECOVERY_CYCLES) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   WIDE_FLASH                     = " "0 (8_BIT_DATA_BUS),1 (16_BIT_DATA_BUS) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ECC_DISABLE                    = " "0 (ECC_ENABLED),1 (ECC_DISABLED) "
  tree.end
 tree.end
  tree "NAND_FLASH_READ_ID"
   group.long 0x40--0x43 "NAND_FLASH_READ_ID (at 0x80008040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   READ_ID                        = "
  tree.end
  tree "NAND_FLASH_READ_STATUS"
   group.long 0x44--0x47 "NAND_FLASH_READ_STATUS (at 0x80008044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   ECC_STATUS                     = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DEV_STATUS                     = "
  tree.end
  tree "NAND_CONTROLLER_CFG"
   group.long 0x48--0x4b "NAND_CONTROLLER_CFG (at 0x80008048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x4--0x1f 1 "  [31: 4]   RESERVED_BITS31_4              = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   EXTERNAL_IF_MODE               = " "0 (THE_INTERNAL_SIGNALS_AND_THE_EXTERNAL_INTERFACE_SIGNALS_ARE_RUNNING_ON_THE_SAME_CLOCK_AND_EDGE),1 (EXTERNAL_INTERFACE_SIGNALS_ARE_RUNNING_ON_EITHER_2X_CLOCK_OR_DIFFERENT_EDGE_OF_SAME_CLOCK) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   ONE_NAND_AD_MUX                = " "0 (SEPARATE_ADDRESS_DATA),1 (ADDRESS_DATA_MUX_MODE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   ONE_NAND_TIE_ALE_CE            = " "0 (DRIVE_ALE_CE_SIGNALS_SEPARATE),1 (ALE_CLE_SIGNALS_WILL_HAVE_SAME_TIMING) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ONE_NAND_BURST_MODE            = " "0 (DISABLE_BURST_MODE),1 (ENABLE_BURST_MODE) "
  tree.end
  tree "NAND_FLASH_CONFIG_DATA"
   group.long 0x50--0x53 "NAND_FLASH_CONFIG_DATA (at 0x80008050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA_IN                        = "
  tree.end
  tree "NAND_FLASH_CONFIG"
   group.long 0x54--0x57 "NAND_FLASH_CONFIG (at 0x80008054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_OUT                       = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   ADDR_OUT                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   DATA_OUT_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xc "  [12:10]   DATA_IN_EN                     = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CS5_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CS4_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CS3_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CS2_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CS1_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CS0_N                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ALE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CLE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   WE_N                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RE_N                           = " "0,1 "
  tree.end
  tree "NAND_FLASH_CONFIG_MODE"
   group.long 0x58--0x5b "NAND_FLASH_CONFIG_MODE (at 0x80008058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS31_1              = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CONFIG_ACC                     = " "0,1 "
  tree.end
  tree "NAND_FLASH_CONFIG_STATUS"
   group.long 0x60--0x63 "NAND_FLASH_CONFIG_STATUS (at 0x80008060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS31_1              = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CONFIG_MODE                    = " "0,1 "
  tree.end
  tree "FLASH_MACRO1_REG"
   group.long 0x64--0x67 "FLASH_MACRO1_REG (at 0x80008064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1f 1 "  [31:20]   RESERVED_BITS31_20             = "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   ADDR_BUS_HOLD_CYCLE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   RESERVED_BITS18_16             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA_START_ADDR                = "
  tree.end
  tree "FLASH_XFR_STEP1"
   group.long 0x70--0x73 "FLASH_XFR_STEP1 (at 0x80008070) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_BOTH_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP2"
   group.long 0x74--0x77 "FLASH_XFR_STEP2 (at 0x80008074) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP3"
   group.long 0x78--0x7b "FLASH_XFR_STEP3 (at 0x80008078) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP4"
   group.long 0x7c--0x7f "FLASH_XFR_STEP4 (at 0x8000807c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP5"
   group.long 0x80--0x83 "FLASH_XFR_STEP5 (at 0x80008080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP6"
   group.long 0x84--0x87 "FLASH_XFR_STEP6 (at 0x80008084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "FLASH_XFR_STEP7"
   group.long 0x88--0x8b "FLASH_XFR_STEP7 (at 0x80008088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   CMD_SEQ_STEP_NUMBER            = " "0 (SIMPLE_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1d 1 "  [29:26]   CMD_STEP1_WAIT                 = "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CMD_AOUT_EN                    = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   CMD_DATA_EN                    = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CMD_CE_EN                      = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CMD_CLE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CMD_ALE_PIN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   CMD_WE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CMD_RE_EN                      = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   CMD_WIDE                       = " "0 (SEND_CMD_ON_8_BIT_BUS),1 (SEND_CMD_ON_16_BIT_BUS) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DATA_SEQ_STEP_NUMBER           = " "0 (SIMPLE_STEPLAST_STEP),1 (LOOP_START),2 (LOOP_END),3 (LAST_STEP) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   DATA_STEP1_WAIT                = "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DATA_AOUT_EN                   = " "0 (ADDRESS_LOGIC_DISABLED),1 (DRIVE_ADDRESS) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DATA_DATA_EN                   = " "0 (DISABLE_DATA_BUS),1 (DRIVE_DATA) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_CE_EN                     = " "0 (DE_ASSERT_CHIP_SELECTS),1 (ASSERT_CHIP_SELECT) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DATA_CLE_EN                    = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   DATA_ALE_PIN                   = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DATA_WE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DATA_RE_EN                     = " "0 (THE_LOGIC_DE_ASSERTS),1 (THE_LOGIC_ASSERTS) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DATA_WIDE                      = " "0 (USE_8_BIT_DATA_BUS_FOR_DATA),1 (USE16_BIT_DATA_BUS_FOR_DATA) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXTA_READ_WAIT                 = " "0,1,2,3 "
  tree.end
  tree "NAND_CTLR_DEBUG_BUS_CFG"
   group.long 0x8c--0x8f "NAND_CTLR_DEBUG_BUS_CFG (at 0x8000808c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   NANDC_DEBUG_SEL                = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   NAND_CTLR_DBG_D31_D16_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   NAND_CTLR_DBG_D15_D0_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   NAND_CTLR_DBG_SWAP             = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
  tree "FLASH_DEV_CMD0"
   group.long 0xa0--0xa3 "FLASH_DEV_CMD0 (at 0x800080a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   WRITE_START                    = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   WRITE_ADDR                     = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   ERASE_START                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ERASE_ADDR                     = "
  tree.end
  tree "FLASH_DEV_CMD1"
   group.long 0xa4--0xa7 "FLASH_DEV_CMD1 (at 0x800080a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   SEQ_READ_MODE_START            = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   SEQ_READ_MODE_ADDR             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   READ_START                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   READ_ADDR                      = "
  tree.end
  tree "FLASH_DEV_CMD2"
   group.long 0xa8--0xab "FLASH_DEV_CMD2 (at 0x800080a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   READ_STOP_CMD                  = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RESET_CMD                      = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   READ_STATUS                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   READ_ID                        = "
  tree.end
  tree "FLASH_DEV_CMD_VLD"
   group.long 0xac--0xaf "FLASH_DEV_CMD_VLD (at 0x800080ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x5--0x1f 1 "  [31: 5]   RESERVED_BITS31_5              = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SEQ_READ_START_VLD             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERASE_START_VLD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WRITE_START_VLD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   READ_STOP_VLD                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   READ_START_VLD                 = " "0,1 "
  tree.end
  tree "EBI2_MISR_SIG_REG"
   group.long 0xb0--0xb3 "EBI2_MISR_SIG_REG (at 0x800080b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EBI2_MISR_SIG                  = "
  tree.end
  tree "NAND_ADDR2"
   group.long 0xc0--0xc3 "NAND_ADDR2 (at 0x800080c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR2                      = "
  tree.end
  tree "NAND_ADDR3"
   group.long 0xc4--0xc7 "NAND_ADDR3 (at 0x800080c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR3                      = "
  tree.end
  tree "NAND_ADDR4"
   group.long 0xc8--0xcb "NAND_ADDR4 (at 0x800080c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR4                      = "
  tree.end
  tree "NAND_ADDR5"
   group.long 0xcc--0xcf "NAND_ADDR5 (at 0x800080cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEV_ADDR5                      = "
  tree.end
  tree "FLASH_DEV_CMD3"
   group.long 0xd0--0xd3 "FLASH_DEV_CMD3 (at 0x800080d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GP_CMD2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GP_CMD1                        = "
  tree.end
  tree "FLASH_DEV_CMD4"
   group.long 0xd4--0xd7 "FLASH_DEV_CMD4 (at 0x800080d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GP_CMD4                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GP_CMD3                        = "
  tree.end
  tree "FLASH_DEV_CMD5"
   group.long 0xd8--0xdb "FLASH_DEV_CMD5 (at 0x800080d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GP_CMD6                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GP_CMD5                        = "
  tree.end
  tree "FLASH_DEV_CMD6"
   group.long 0xdc--0xdf "FLASH_DEV_CMD6 (at 0x800080dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GP_CMD8                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GP_CMD7                        = "
  tree.end
  tree "FLASH_BURST_CFG"
   group.long 0xe0--0xe3 "FLASH_BURST_CFG (at 0x800080e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_BITS31_12             = "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   DIV2_MODE                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x6--0xa 1 "  [10: 6]   BURST_PAGE_SIZE                = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   ONE_NAND_PAGE_GAP              = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OE_RDY_SAMPLE_GAP              = " "0,1,2,3 "
  tree.end
  tree "EBI2_ECC_BUF_CFG"
   group.long 0xf0--0xf3 "EBI2_ECC_BUF_CFG (at 0x800080f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   CW_USER_DATA_LENGTH            = "
  tree.end
  tree "NAND_FLASH_BIT_STREAM"
   group.long 0xf4--0xf7 "NAND_FLASH_BIT_STREAM (at 0x800080f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x6--0x1f 1 "  [31: 6]   RESERVED_BITS31_6              = "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PAGE_ERASED                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PAGE_CLEARED                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RESERVED_BITS3_1               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   BIT_STREAM_ECC_MASK            = " "0 (ECC_CORRECTION_IS_NOT_MASKED),1 (DISABLE_ECC_CORRECTION_WHEN_AN_ERASED_PAGE_IS_DETECTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BIT_STREAM_CTRL_RES            = " "0 (ENABLE_THE_CONTROLLER_TO_CHECK_THE_DATA_AS_IT_ARRIVES),1 (RESET_THE_BIT_STREAM_CONTROLLER) "
  tree.end
 tree "FLASH_BUFFn_ACC"
  tree "FLASH_BUFF0_ACC"
   group.long 0x100--0x103 "FLASH_BUFF0_ACC (at 0x80008100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF1_ACC"
   group.long 0x104--0x107 "FLASH_BUFF1_ACC (at 0x80008104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF2_ACC"
   group.long 0x108--0x10b "FLASH_BUFF2_ACC (at 0x80008108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF3_ACC"
   group.long 0x10c--0x10f "FLASH_BUFF3_ACC (at 0x8000810c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF4_ACC"
   group.long 0x110--0x113 "FLASH_BUFF4_ACC (at 0x80008110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF5_ACC"
   group.long 0x114--0x117 "FLASH_BUFF5_ACC (at 0x80008114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF6_ACC"
   group.long 0x118--0x11b "FLASH_BUFF6_ACC (at 0x80008118) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF7_ACC"
   group.long 0x11c--0x11f "FLASH_BUFF7_ACC (at 0x8000811c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF8_ACC"
   group.long 0x120--0x123 "FLASH_BUFF8_ACC (at 0x80008120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF9_ACC"
   group.long 0x124--0x127 "FLASH_BUFF9_ACC (at 0x80008124) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF10_ACC"
   group.long 0x128--0x12b "FLASH_BUFF10_ACC (at 0x80008128) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF11_ACC"
   group.long 0x12c--0x12f "FLASH_BUFF11_ACC (at 0x8000812c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF12_ACC"
   group.long 0x130--0x133 "FLASH_BUFF12_ACC (at 0x80008130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF13_ACC"
   group.long 0x134--0x137 "FLASH_BUFF13_ACC (at 0x80008134) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF14_ACC"
   group.long 0x138--0x13b "FLASH_BUFF14_ACC (at 0x80008138) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF15_ACC"
   group.long 0x13c--0x13f "FLASH_BUFF15_ACC (at 0x8000813c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF16_ACC"
   group.long 0x140--0x143 "FLASH_BUFF16_ACC (at 0x80008140) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF17_ACC"
   group.long 0x144--0x147 "FLASH_BUFF17_ACC (at 0x80008144) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF18_ACC"
   group.long 0x148--0x14b "FLASH_BUFF18_ACC (at 0x80008148) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF19_ACC"
   group.long 0x14c--0x14f "FLASH_BUFF19_ACC (at 0x8000814c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF20_ACC"
   group.long 0x150--0x153 "FLASH_BUFF20_ACC (at 0x80008150) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF21_ACC"
   group.long 0x154--0x157 "FLASH_BUFF21_ACC (at 0x80008154) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF22_ACC"
   group.long 0x158--0x15b "FLASH_BUFF22_ACC (at 0x80008158) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF23_ACC"
   group.long 0x15c--0x15f "FLASH_BUFF23_ACC (at 0x8000815c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF24_ACC"
   group.long 0x160--0x163 "FLASH_BUFF24_ACC (at 0x80008160) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF25_ACC"
   group.long 0x164--0x167 "FLASH_BUFF25_ACC (at 0x80008164) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF26_ACC"
   group.long 0x168--0x16b "FLASH_BUFF26_ACC (at 0x80008168) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF27_ACC"
   group.long 0x16c--0x16f "FLASH_BUFF27_ACC (at 0x8000816c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF28_ACC"
   group.long 0x170--0x173 "FLASH_BUFF28_ACC (at 0x80008170) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF29_ACC"
   group.long 0x174--0x177 "FLASH_BUFF29_ACC (at 0x80008174) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF30_ACC"
   group.long 0x178--0x17b "FLASH_BUFF30_ACC (at 0x80008178) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF31_ACC"
   group.long 0x17c--0x17f "FLASH_BUFF31_ACC (at 0x8000817c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF32_ACC"
   group.long 0x180--0x183 "FLASH_BUFF32_ACC (at 0x80008180) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF33_ACC"
   group.long 0x184--0x187 "FLASH_BUFF33_ACC (at 0x80008184) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF34_ACC"
   group.long 0x188--0x18b "FLASH_BUFF34_ACC (at 0x80008188) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF35_ACC"
   group.long 0x18c--0x18f "FLASH_BUFF35_ACC (at 0x8000818c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF36_ACC"
   group.long 0x190--0x193 "FLASH_BUFF36_ACC (at 0x80008190) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF37_ACC"
   group.long 0x194--0x197 "FLASH_BUFF37_ACC (at 0x80008194) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF38_ACC"
   group.long 0x198--0x19b "FLASH_BUFF38_ACC (at 0x80008198) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF39_ACC"
   group.long 0x19c--0x19f "FLASH_BUFF39_ACC (at 0x8000819c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF40_ACC"
   group.long 0x1a0--0x1a3 "FLASH_BUFF40_ACC (at 0x800081a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF41_ACC"
   group.long 0x1a4--0x1a7 "FLASH_BUFF41_ACC (at 0x800081a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF42_ACC"
   group.long 0x1a8--0x1ab "FLASH_BUFF42_ACC (at 0x800081a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF43_ACC"
   group.long 0x1ac--0x1af "FLASH_BUFF43_ACC (at 0x800081ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF44_ACC"
   group.long 0x1b0--0x1b3 "FLASH_BUFF44_ACC (at 0x800081b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF45_ACC"
   group.long 0x1b4--0x1b7 "FLASH_BUFF45_ACC (at 0x800081b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF46_ACC"
   group.long 0x1b8--0x1bb "FLASH_BUFF46_ACC (at 0x800081b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF47_ACC"
   group.long 0x1bc--0x1bf "FLASH_BUFF47_ACC (at 0x800081bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF48_ACC"
   group.long 0x1c0--0x1c3 "FLASH_BUFF48_ACC (at 0x800081c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF49_ACC"
   group.long 0x1c4--0x1c7 "FLASH_BUFF49_ACC (at 0x800081c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF50_ACC"
   group.long 0x1c8--0x1cb "FLASH_BUFF50_ACC (at 0x800081c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF51_ACC"
   group.long 0x1cc--0x1cf "FLASH_BUFF51_ACC (at 0x800081cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF52_ACC"
   group.long 0x1d0--0x1d3 "FLASH_BUFF52_ACC (at 0x800081d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF53_ACC"
   group.long 0x1d4--0x1d7 "FLASH_BUFF53_ACC (at 0x800081d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF54_ACC"
   group.long 0x1d8--0x1db "FLASH_BUFF54_ACC (at 0x800081d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF55_ACC"
   group.long 0x1dc--0x1df "FLASH_BUFF55_ACC (at 0x800081dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF56_ACC"
   group.long 0x1e0--0x1e3 "FLASH_BUFF56_ACC (at 0x800081e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF57_ACC"
   group.long 0x1e4--0x1e7 "FLASH_BUFF57_ACC (at 0x800081e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF58_ACC"
   group.long 0x1e8--0x1eb "FLASH_BUFF58_ACC (at 0x800081e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF59_ACC"
   group.long 0x1ec--0x1ef "FLASH_BUFF59_ACC (at 0x800081ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF60_ACC"
   group.long 0x1f0--0x1f3 "FLASH_BUFF60_ACC (at 0x800081f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF61_ACC"
   group.long 0x1f4--0x1f7 "FLASH_BUFF61_ACC (at 0x800081f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF62_ACC"
   group.long 0x1f8--0x1fb "FLASH_BUFF62_ACC (at 0x800081f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF63_ACC"
   group.long 0x1fc--0x1ff "FLASH_BUFF63_ACC (at 0x800081fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF64_ACC"
   group.long 0x200--0x203 "FLASH_BUFF64_ACC (at 0x80008200) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF65_ACC"
   group.long 0x204--0x207 "FLASH_BUFF65_ACC (at 0x80008204) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF66_ACC"
   group.long 0x208--0x20b "FLASH_BUFF66_ACC (at 0x80008208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF67_ACC"
   group.long 0x20c--0x20f "FLASH_BUFF67_ACC (at 0x8000820c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF68_ACC"
   group.long 0x210--0x213 "FLASH_BUFF68_ACC (at 0x80008210) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF69_ACC"
   group.long 0x214--0x217 "FLASH_BUFF69_ACC (at 0x80008214) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF70_ACC"
   group.long 0x218--0x21b "FLASH_BUFF70_ACC (at 0x80008218) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF71_ACC"
   group.long 0x21c--0x21f "FLASH_BUFF71_ACC (at 0x8000821c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF72_ACC"
   group.long 0x220--0x223 "FLASH_BUFF72_ACC (at 0x80008220) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF73_ACC"
   group.long 0x224--0x227 "FLASH_BUFF73_ACC (at 0x80008224) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF74_ACC"
   group.long 0x228--0x22b "FLASH_BUFF74_ACC (at 0x80008228) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF75_ACC"
   group.long 0x22c--0x22f "FLASH_BUFF75_ACC (at 0x8000822c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF76_ACC"
   group.long 0x230--0x233 "FLASH_BUFF76_ACC (at 0x80008230) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF77_ACC"
   group.long 0x234--0x237 "FLASH_BUFF77_ACC (at 0x80008234) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF78_ACC"
   group.long 0x238--0x23b "FLASH_BUFF78_ACC (at 0x80008238) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF79_ACC"
   group.long 0x23c--0x23f "FLASH_BUFF79_ACC (at 0x8000823c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF80_ACC"
   group.long 0x240--0x243 "FLASH_BUFF80_ACC (at 0x80008240) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF81_ACC"
   group.long 0x244--0x247 "FLASH_BUFF81_ACC (at 0x80008244) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF82_ACC"
   group.long 0x248--0x24b "FLASH_BUFF82_ACC (at 0x80008248) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF83_ACC"
   group.long 0x24c--0x24f "FLASH_BUFF83_ACC (at 0x8000824c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF84_ACC"
   group.long 0x250--0x253 "FLASH_BUFF84_ACC (at 0x80008250) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF85_ACC"
   group.long 0x254--0x257 "FLASH_BUFF85_ACC (at 0x80008254) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF86_ACC"
   group.long 0x258--0x25b "FLASH_BUFF86_ACC (at 0x80008258) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF87_ACC"
   group.long 0x25c--0x25f "FLASH_BUFF87_ACC (at 0x8000825c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF88_ACC"
   group.long 0x260--0x263 "FLASH_BUFF88_ACC (at 0x80008260) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF89_ACC"
   group.long 0x264--0x267 "FLASH_BUFF89_ACC (at 0x80008264) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF90_ACC"
   group.long 0x268--0x26b "FLASH_BUFF90_ACC (at 0x80008268) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF91_ACC"
   group.long 0x26c--0x26f "FLASH_BUFF91_ACC (at 0x8000826c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF92_ACC"
   group.long 0x270--0x273 "FLASH_BUFF92_ACC (at 0x80008270) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF93_ACC"
   group.long 0x274--0x277 "FLASH_BUFF93_ACC (at 0x80008274) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF94_ACC"
   group.long 0x278--0x27b "FLASH_BUFF94_ACC (at 0x80008278) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF95_ACC"
   group.long 0x27c--0x27f "FLASH_BUFF95_ACC (at 0x8000827c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF96_ACC"
   group.long 0x280--0x283 "FLASH_BUFF96_ACC (at 0x80008280) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF97_ACC"
   group.long 0x284--0x287 "FLASH_BUFF97_ACC (at 0x80008284) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF98_ACC"
   group.long 0x288--0x28b "FLASH_BUFF98_ACC (at 0x80008288) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF99_ACC"
   group.long 0x28c--0x28f "FLASH_BUFF99_ACC (at 0x8000828c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF100_ACC"
   group.long 0x290--0x293 "FLASH_BUFF100_ACC (at 0x80008290) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF101_ACC"
   group.long 0x294--0x297 "FLASH_BUFF101_ACC (at 0x80008294) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF102_ACC"
   group.long 0x298--0x29b "FLASH_BUFF102_ACC (at 0x80008298) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF103_ACC"
   group.long 0x29c--0x29f "FLASH_BUFF103_ACC (at 0x8000829c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF104_ACC"
   group.long 0x2a0--0x2a3 "FLASH_BUFF104_ACC (at 0x800082a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF105_ACC"
   group.long 0x2a4--0x2a7 "FLASH_BUFF105_ACC (at 0x800082a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF106_ACC"
   group.long 0x2a8--0x2ab "FLASH_BUFF106_ACC (at 0x800082a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF107_ACC"
   group.long 0x2ac--0x2af "FLASH_BUFF107_ACC (at 0x800082ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF108_ACC"
   group.long 0x2b0--0x2b3 "FLASH_BUFF108_ACC (at 0x800082b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF109_ACC"
   group.long 0x2b4--0x2b7 "FLASH_BUFF109_ACC (at 0x800082b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF110_ACC"
   group.long 0x2b8--0x2bb "FLASH_BUFF110_ACC (at 0x800082b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF111_ACC"
   group.long 0x2bc--0x2bf "FLASH_BUFF111_ACC (at 0x800082bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF112_ACC"
   group.long 0x2c0--0x2c3 "FLASH_BUFF112_ACC (at 0x800082c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF113_ACC"
   group.long 0x2c4--0x2c7 "FLASH_BUFF113_ACC (at 0x800082c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF114_ACC"
   group.long 0x2c8--0x2cb "FLASH_BUFF114_ACC (at 0x800082c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF115_ACC"
   group.long 0x2cc--0x2cf "FLASH_BUFF115_ACC (at 0x800082cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF116_ACC"
   group.long 0x2d0--0x2d3 "FLASH_BUFF116_ACC (at 0x800082d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF117_ACC"
   group.long 0x2d4--0x2d7 "FLASH_BUFF117_ACC (at 0x800082d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF118_ACC"
   group.long 0x2d8--0x2db "FLASH_BUFF118_ACC (at 0x800082d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF119_ACC"
   group.long 0x2dc--0x2df "FLASH_BUFF119_ACC (at 0x800082dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF120_ACC"
   group.long 0x2e0--0x2e3 "FLASH_BUFF120_ACC (at 0x800082e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF121_ACC"
   group.long 0x2e4--0x2e7 "FLASH_BUFF121_ACC (at 0x800082e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF122_ACC"
   group.long 0x2e8--0x2eb "FLASH_BUFF122_ACC (at 0x800082e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF123_ACC"
   group.long 0x2ec--0x2ef "FLASH_BUFF123_ACC (at 0x800082ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF124_ACC"
   group.long 0x2f0--0x2f3 "FLASH_BUFF124_ACC (at 0x800082f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF125_ACC"
   group.long 0x2f4--0x2f7 "FLASH_BUFF125_ACC (at 0x800082f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF126_ACC"
   group.long 0x2f8--0x2fb "FLASH_BUFF126_ACC (at 0x800082f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF127_ACC"
   group.long 0x2fc--0x2ff "FLASH_BUFF127_ACC (at 0x800082fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF128_ACC"
   group.long 0x300--0x303 "FLASH_BUFF128_ACC (at 0x80008300) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF129_ACC"
   group.long 0x304--0x307 "FLASH_BUFF129_ACC (at 0x80008304) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF130_ACC"
   group.long 0x308--0x30b "FLASH_BUFF130_ACC (at 0x80008308) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "FLASH_BUFF131_ACC"
   group.long 0x30c--0x30f "FLASH_BUFF131_ACC (at 0x8000830c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
 tree.end
tree.end

base ad:0x80000000
tree "CLK"
  tree "ARM_MOD_REG"
   group.long 0x0--0x3 "ARM_MOD_REG (at 0x80000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ARM_DIV_MOD0                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ARM_DIV_MOD1                   = "
  tree.end
  tree "ARM_CFG_REG"
   group.long 0x4--0x7 "ARM_CFG_REG (at 0x80000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe "  [   14]   ARM_SLEEP_WFI                  = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   AHB_VOTE_EN                    = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   AHB_SLEEP_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   EBI2_RATE_SEL                  = " "0 (DIV_1),1 (DIV_2),2 (DIV_4),3 (DIV_8) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   EBI1_RATE_SEL                  = " "0 (DIV_1),1 (DIV_2),2 (DIV_4),3 (DIV_8) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   AHB_RATE_SEL                   = " "0 (DIV_1),1 (DIV_2),2 (DIV_4),3 (DIV_8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   ARM_RATE_SEL                   = " "0 (DIV_1),1 (DIV_2) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ARM_SRC_SEL                    = " "0 (ARM_SRC0),1 (ARM_SRC1) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SRC_SEL1                       = " "0 (XO),1 (PLL_SRC),2 (SLEEP_CLK),3 (EXT_CLK) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SRC_SEL0                       = " "0 (XO),1 (PLL_SRC),2 (SLEEP_CLK),3 (EXT_CLK) "
  tree.end
  tree "ARM_CLK_EN_REG"
   group.long 0x8--0xb "ARM_CLK_EN_REG (at 0x80000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   EBI2_CLK_SRC_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   VIDEO_AHB_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   MDP_AHB_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   SDCC_AHB_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   PERPH_WEB_AHB_CLK_EN           = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TLMM_GPIO_AHB_CLK_EN           = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   UXMC_AHB_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   ADSP_AHB_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   AUDIO_AHB_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   GSBI_AHB_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   MTI_AHB_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   MODEM_AHB_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   PERIPH_AHB_CLK_EN              = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   USB_AHB_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   SEC_AHB_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   AHB_AHB_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   UART_DM_AHB_CLK_EN             = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ETM_CLK_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   EBI1_IO_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   EBI1_CLK_EN                    = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   IMEM_CLK_SRC_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ARM_CLK_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
  tree.end
  tree "ARM_CLK_INV_REG"
   group.long 0xf0--0xf3 "ARM_CLK_INV_REG (at 0x800000f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   EBI2_CLK_SRC_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   VIDEO_AHB_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   MDP_AHB_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   SDCC_AHB_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   PERPH_WEB_AHB_CLK_INV          = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TLMM_GPIO_AHB_CLK_INV          = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   UXMC_AHB_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   ADSP_AHB_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   AUDIO_AHB_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   GSBI_AHB_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   MTI_AHB_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   MODEM_AHB_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   PERIPH_AHB_CLK_INV             = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   USB_AHB_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   SEC_AHB_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   AHB_AHB_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   UART_DM_AHB_CLK_INV            = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ETM_CLK_INV                    = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   EBI1_IO_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   EBI1_CLK_INV                   = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   IMEM_CLK_SRC_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ARM_CLK_INV                    = " "0 (NOT_INVERTED),1 (INVERTED) "
  tree.end
  tree "ADSP_MND0_REG"
   group.long 0x10--0x13 "ADSP_MND0_REG (at 0x80000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   M_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   N_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   D_VAL                          = "
  tree.end
  tree "ADSP_MND1_REG"
   group.long 0x14--0x17 "ADSP_MND1_REG (at 0x80000014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   M_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   N_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   D_VAL                          = "
  tree.end
  tree "ADSP_CFG_REG"
   group.long 0x18--0x1b "ADSP_CFG_REG (at 0x80000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   ADSP_MODE_SWITCH_EN            = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   TIMEOUT_COUNTER_DLY            = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   ADSP_CLK_CTL_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   ADSP_CLK_OVR_N                 = " "0 (OVERRIDDEN),1 (NOT_OVERRIDDEN) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   ADSP_DME_CLK_OVR_N             = " "0 (OVERRIDDEN),1 (NOT_OVERRIDDEN) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ADSP_DMA_CLK_OVR_N             = " "0 (OVERRIDDEN),1 (NOT_OVERRIDDEN) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   ADSP_INTF_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   ADSP_INTF_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   ADSP_CLK_INV                   = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ADSP_CLK_EN                    = " "0 (NOT_ENABLED),1 (ENABLED) "
  tree.end
  tree "ADSP_CLK_CTL_REG"
   group.long 0x54--0x57 "ADSP_CLK_CTL_REG (at 0x80000054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   ADSP_VIDEO_INTF_CLK_INV        = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   ADSP_VIDEO_INTF_CLK_EN         = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   ADSP_SRC_SEL                   = " "0 (ADSP_SRC0),1 (ADSP_SRC1) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DIV_MND_MODE1                  = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DIV_MND_EN1                    = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DIV_MND_MODE0                  = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DIV_MND_EN0                    = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SRC_SEL1                       = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SRC_SEL0                       = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
  tree.end
  tree "ADSP_MODE_REG"
   group.long 0xfc--0xff "ADSP_MODE_REG (at 0x800000fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ADSPCLK_1X_MODE                = " "0 (2X_MODE),1 (1X_MODE) "
  tree.end
  tree "ADSP_FS_CTL_REG"
   group.long 0x100--0x103 "ADSP_FS_CTL_REG (at 0x80000100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   FS_FORCE_ON                    = " "0 (NORMAL_MODE),1 (FORCE_ON) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FS_S                           = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FS_W                           = "
  tree.end
  tree "ECODEC_MN_REG"
   group.long 0x1c--0x1f "ECODEC_MN_REG (at 0x8000001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "ECODEC_CD_REG"
   group.long 0x20--0x23 "ECODEC_CD_REG (at 0x80000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c "  [   28]   ECODECIF_DIV_MOD               = " "0 (DIV_1),1 (DIV_2) "
    textline ""
    bitfld.long 0x0 0x1b "  [   27]   ECODECIF_PO_CLK_INV            = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x1a "  [   26]   ECODECIF_PO_CLK_EN             = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   ECODECIF_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   ECODECIF_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   ECODEC_CLK_INV                 = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   ECODEC_CLK_EN                  = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK),4 (AUX_PCM_CLK_BI),5 (reserved),6 (reserved),7 (7_CLOCKS) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "GSBI0_MN_REG"
   group.long 0x2c--0x2f "GSBI0_MN_REG (at 0x8000002c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "GSBI0_CD_REG"
   group.long 0x30--0x33 "GSBI0_CD_REG (at 0x80000030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d "  [   29]   GSBI0_SIM_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x1c "  [   28]   GSBI0_SIM_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   SIM_DIV_MOD                    = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   SIM_SRC_SEL                    = " "0 (GSBI0_MND),1 (XO) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   GSBI0_CLK_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   GSBI0_CLK_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "GSBI1_MN_REG"
   group.long 0x34--0x37 "GSBI1_MN_REG (at 0x80000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   M_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   N_VAL                          = "
  tree.end
  tree "GSBI1_CD_REG"
   group.long 0x38--0x3b "GSBI1_CD_REG (at 0x80000038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe "  [   14]   GSBI1_CLK_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   GSBI1_CLK_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   D_VAL                          = "
  tree.end
  tree "GSBI2_MN_REG"
   group.long 0xd4--0xd7 "GSBI2_MN_REG (at 0x800000d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   M_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   N_VAL                          = "
  tree.end
  tree "GSBI2_CD_REG"
   group.long 0xd8--0xdb "GSBI2_CD_REG (at 0x800000d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe "  [   14]   GSBI2_CLK_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   GSBI2_CLK_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   D_VAL                          = "
  tree.end
  tree "I2S_MN_REG"
   group.long 0x3c--0x3f "I2S_MN_REG (at 0x8000003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "I2S_CD_REG"
   group.long 0x40--0x43 "I2S_CD_REG (at 0x80000040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a "  [   26]   I2S_BIT_CLK_DIV                = " "0 (DIV_8),1 (DIV_1) "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   I2S_BIT_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   I2S_BIT_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   I2S_MSTR_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   I2S_MSTR_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK),4 (AUX_PCM_CLK_BI),5 (AUX_PCM_DIN_BI),6 (reserved),7 (DIV_8) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "ICODEC_RX_MN_REG"
   group.long 0x44--0x47 "ICODEC_RX_MN_REG (at 0x80000044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "ICODEC_RX_CD_REG"
   group.long 0x48--0x4b "ICODEC_RX_CD_REG (at 0x80000048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c "  [   28]   2X_RX_CLK_INV_SEL              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x1b "  [   27]   RX_CLK_INV_SEL                 = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x1a "  [   26]   ICODEC_RX_TO_I2S_CLK_INV       = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   ICODEC_RX_TO_I2S_CLK_EN        = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   ICODEC_RX_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   ICODEC_RX_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   ICODEC_2X_RX_CLK_INV           = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   ICODEC_2X_RX_CLK_EN            = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "ICODEC_TX_MN_REG"
   group.long 0x4c--0x4f "ICODEC_TX_MN_REG (at 0x8000004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "ICODEC_TX_CD_REG"
   group.long 0x50--0x53 "ICODEC_TX_CD_REG (at 0x80000050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   CLK_SEL                        = " "0 (ICODEC_TX),1 (ICODEC_RX) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   ICODEC_TX_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   ICODEC_TX_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "SDCC_MN_REG"
   group.long 0xe0--0xe3 "SDCC_MN_REG (at 0x800000e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "SDCC_CD_REG"
   group.long 0xe4--0xe7 "SDCC_CD_REG (at 0x800000e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   SDCC_CLK_INV                   = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   SDCC_CLK_EN                    = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "MISC_CFG_REG"
   group.long 0x90--0x93 "MISC_CFG_REG (at 0x80000090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   EXTERNAL_CLK_SEL               = " "0 (EXT_CLK1),1 (EXT_CLK2) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   EXTERNAL_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   SSBI_PMIC_SRC_SEL              = " "0 (EXT_CLK),1 (XO) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   RXADC_SRC_SEL                  = " "0 (EXT_CLK),1 (XO) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   RFMS_XO_SRC_SEL                = " "0 (EXT_CLK),1 (XO) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   RFMS_XO_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   RFMS_XO_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   I2C_CLK_INV                    = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   I2C_CLK_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   I2C_SRC_SEL                    = " "0 (EXT_CLK),1 (XO),2 (SLEEP_CLK),3 (XO4) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   RXADC_CLK_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   RXADC_CLK_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   WDOG_SLP_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   XO4_CLK_INV                    = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   XO4_CLK_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   SSBI_PMIC_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SSBI_PMIC_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   QMEMBIST_CLK_INV               = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   QMEMBIST_CLK_EN                = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   QMEMBIST_SRC_SEL               = " "0 (EXT_CLK),1 (XO),2 (TCB_JTAG_CLK),3 (GND_TIE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   EFUSE_CLK_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EFUSE_CLK_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
  tree.end
  tree "UART_DM_MN_REG"
   group.long 0xf4--0xf7 "UART_DM_MN_REG (at 0x800000f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "UART_DM_CD_REG"
   group.long 0xf8--0xfb "UART_DM_CD_REG (at 0x800000f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   UART_DM_CLK_INV                = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   UART_DM_CLK_EN                 = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "USB_MN_REG"
   group.long 0x94--0x97 "USB_MN_REG (at 0x80000094) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   M_VAL                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   N_VAL                          = "
  tree.end
  tree "USB_CD_REG"
   group.long 0xc0--0xc3 "USB_CD_REG (at 0x800000c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe "  [   14]   USB_FS_CLK_INV                 = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   USB_FS_CLK_EN                  = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   SRC_SEL                        = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   D_VAL                          = "
  tree.end
  tree "CAMCLK_MN_REG"
   group.long 0x104--0x107 "CAMCLK_MN_REG (at 0x80000104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "CAMCLK_CD_REG"
   group.long 0x108--0x10b "CAMCLK_CD_REG (at 0x80000108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   CAM_PCLK_INVERT                = " "0 (DO_NOT_INVERT),1 (INVERT) "
    textline ""
    bitfld.long 0x0 0x17--0x18 "  [24:23]   CAM_PCLK_SRC_SEL               = " "0 (TCB_SHADOW_TCK),1 (NO_CLOCK),2 (VIDEO_VFE_CLK),3 (TLMM_CAM_PCLK) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CAMCLK_PO_INV                  = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   CAMCLK_PO_EN                   = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CAMCLK_PO_SRC_SEL              = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "VIDEO_VFE_MN_REG"
   group.long 0xe8--0xeb "VIDEO_VFE_MN_REG (at 0x800000e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   M_VAL                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   N_VAL                          = "
  tree.end
  tree "VIDEO_VFE_CD_REG"
   group.long 0xec--0xef "VIDEO_VFE_CD_REG (at 0x800000ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   VIDEO_VFE_CLK_INV              = " "0 (NOT_INVERTED),1 (INVERTED) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   VIDEO_VFE_CLK_EN               = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x15--0x16 "  [22:21]   VIDEO_VFE_CLK_SRC_SEL          = " "0 (VIDEO_VFE_DIV_MND),1 (CAMCLK_PO),2 (CAMIF_PCLK),3 (GND_TIE) "
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   DIV_MND_MODE                   = " "0 (BYPASS),1 (CLOCK_SWALLOW_MODE),2 (DUAL_EDGE_MODE),3 (SINGLE_EDGE_MODE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   DIV_MND_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   VIDEO_VFE_SRC_SEL              = " "0 (EXT_CLK),1 (XO),2 (PLL_SRC),3 (SLEEP_CLK) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   D_VAL                          = "
  tree.end
  tree "CLK_OFF_A"
   group.long 0xc4--0xc7 "CLK_OFF_A (at 0x800000c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EBI2_CLK_SRC                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIDEO_AHB_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MDP_AHB_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   SDCC_AHB_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   PERPH_WEB_AHB_CLK              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TLMM_GPIO_AHB_CLK              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   UXMC_AHB_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   USB_AHB_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_AHB_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   AUDIO_AHB_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GSBI_AHB_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MODEM_AHB_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MTI_AHB_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PERIPH_AHB_CLK                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SEC_AHB_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AHB_AHB_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   UART_DM_AHB_CLK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   IMEM_CLK_SRC                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EBI1_IO_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI1_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   ETM_CLK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARM_CLK                        = " "0,1 "
  tree.end
  tree "CLK_OFF_B"
   group.long 0xc8--0xcb "CLK_OFF_B (at 0x800000c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   GSBI0_SIM_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   ICODEC_RX_TO_I2S_CLK           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART_DM_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   VIDEO_VFE_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   CAMCLK_PO                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RFMS_XO_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SDCC_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   I2C_CLK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GSBI2_CLK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RXADC_CLK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   XO4_CLK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   WDOG_SLP_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_FS_CLK                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SSBI_PMIC_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   QMEMBIST_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ICODEC_TX_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   ICODEC_RX_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   ICODEC_2X_RX_CLK               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2S_BIT_CLK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   I2S_MSTR_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   GSBI1_CLK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GSBI0_CLK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   ADSP_VIDEO_INTF_CLK            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EFUSE_CLK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ECODECIF_PO_CLK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ECODECIF_CLK                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   ECODEC_CLK                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   ADSP_INTF_CLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ADSP_CLK                       = " "0,1 "
  tree.end
  tree "DBG_CFG_REG"
   group.long 0xd0--0xd3 "DBG_CFG_REG (at 0x800000d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   FAIL_BOOT_VAL                  = " "0 (LOW),1 (AHB_CLK_DIV2),2 (AHB_CLK_DIV3),3 (AHB_CLK_DIV4),4 (AHB_CLK_DIV5),5 (AHB_CLK_DIV6),6 (AHB_CLK_DIV7),7 (HIGH) "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   BUS_SEL                        = " "0 (DISABLED),1 (CLK_OFF_A),2 (CLK_OFF_B),3 (PLL_STATUS) "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   CLK_SEL                        = "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DBG_CLK_EN                     = " "0 (NOT_ENABLED),1 (ENABLED) "
  tree.end
  tree "SW_RESET_ALL_REG"
   group.long 0x200--0x203 "SW_RESET_ALL_REG (at 0x80000200) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SW_RESET_ALL                   = " "0 (NOT_ACTIVE),1 (ACTIVE) "
  tree.end
  tree "RESET_STATUS_REG"
   group.long 0x204--0x207 "RESET_STATUS_REG (at 0x80000204)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RESET_STATUS                   = " "0 (RESIN),1 (WDOG_EXPIRED) "
  tree.end
  tree "SW_RESET_REG"
   group.long 0x208--0x20b "SW_RESET_REG (at 0x80000208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a "  [   26]   EBI2_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   UART_DM_RESET                  = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   VIDEO_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   MDP_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CAMIF_PAD_REG_RESET            = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   RFMS_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   SDCC_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   I2C_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   GSBI2_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   RXADC_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   IMEM_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   SSBI_PMIC_RESET                = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   GSBI1_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   GSBI0_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   MODEM_RESET                    = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   EBI1_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   SEC_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   WDOG_SLP_RESET                 = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   QMEMBIST_RESET                 = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   XO4_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   ECODECIF_RESET                 = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   ADSP_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ICODEC_TX_RESET                = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   ICODEC_RX_RESET                = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   USB_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   SDAC_RESET                     = " "0 (NOT_ACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ETM_RESET                      = " "0 (NOT_ACTIVE),1 (ACTIVE) "
  tree.end
  tree "PLL_TESTPAD_CFG_REG"
   group.long 0xcc--0xcf "PLL_TESTPAD_CFG_REG (at 0x800000cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SE_PULL                        = " "0 (NONE),1 (PULLDOWN),2 (KEEP),3 (PULL_UP) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SE_OE                          = " "0 (DISABLE),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   SE_HDRIVE                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SE_BIAS                        = " "0,1,2,3 "
  tree.end
  tree "PLL_MODE_REG"
   group.long 0x300--0x303 "PLL_MODE_REG (at 0x80000300) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PLLTEST                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RESET_N                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BYPASSNL                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OUTCTRL                        = " "0,1 "
  tree.end
  tree "PLL_L_VAL_REG"
   group.long 0x308--0x30b "PLL_L_VAL_REG (at 0x80000308) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PLL_L                          = "
  tree.end
  tree "PLL_M_VAL_REG"
   group.long 0x30c--0x30f "PLL_M_VAL_REG (at 0x8000030c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   PLL_M                          = "
  tree.end
  tree "PLL_N_VAL_REG"
   group.long 0x310--0x313 "PLL_N_VAL_REG (at 0x80000310) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   PLL_N                          = "
  tree.end
  tree "PLL_CONFIG_REG"
   group.long 0x314--0x317 "PLL_CONFIG_REG (at 0x80000314) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   PLL_CONFIG                     = "
  tree.end
  tree "PLL_TEST_CTL_REG"
   group.long 0x318--0x31b "PLL_TEST_CTL_REG (at 0x80000318) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   PLL_TEST_CTL_REG               = "
  tree.end
  tree "PLL_STATUS_REG"
   group.long 0x31c--0x31f "PLL_STATUS_REG (at 0x8000031c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   PLL_CLOCKDET_OUT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   PLL_TESTOUT                    = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PLL_STATUS                     = "
  tree.end
tree.end

base ad:0x8002a000
tree "DEBUG_REGS"
  tree "UXMC_DEBUG_BUS_CTRL"
   group.long 0x0--0x3 "UXMC_DEBUG_BUS_CTRL (at 0x8002a000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xb--0x1f 1 "  [31:11]   RESERVED_BIT31_10              = "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   IO_TIME_DBG_BUS_SEL            = " "0 (IO_TIME_DBG_BUS0),1 (IO_TIME_DBG_BUS1),2 (IO_TIME_DBG_BUS2),3 (reserved),4 (RD_FIFO_DIAG0),5 (RD_FIFO_DIAG1),6 (reserved),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IO_TIME_DBG_D31_D16_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   IO_TIME_DBG_D15_D0_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   IO_TIME_DBG_SWAP               = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   IO_MUX_DBG_D31_D16_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IO_MUX_DBG_D15_D0_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   IO_MUX_DBG_SWAP                = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
tree.end

base ad:0x90001300
tree "DECOB"
  tree "DECOB_RESET"
   group.long 0x0--0x3 "DECOB_RESET (at 0x90001300)   (shadowed - Use hwio_shadow_ptr->DECOB_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "DECOB_BURST_IF_ACCESS"
   group.long 0x4--0x7 "DECOB_BURST_IF_ACCESS (at 0x90001304)   (shadowed - Use hwio_shadow_ptr->DECOB_BURST_IF_ACCESS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BURST_IF_ACCESS                = " "0,1 "
  tree.end
  tree "DECOB_LONG_BUFFER_ADDR"
   group.long 0x8--0xb "DECOB_LONG_BUFFER_ADDR (at 0x90001308)   (shadowed - Use hwio_shadow_ptr->DECOB_LONG_BUFFER_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   ADDRESS                        = "
  tree.end
  tree "DECOB_LONG_BUFFER_DATA"
   group.long 0xc--0xf "DECOB_LONG_BUFFER_DATA (at 0x9000130c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DECOB_SHORT_BUFFER_ADDR"
   group.long 0x10--0x13 "DECOB_SHORT_BUFFER_ADDR (at 0x90001310) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ADDRESS                        = "
  tree.end
  tree "DECOB_SHORT_BUFFER_DATA"
   group.long 0x14--0x17 "DECOB_SHORT_BUFFER_DATA (at 0x90001314)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "DECOB_LONG_BUFFER_HUNT_CHAR"
   group.long 0x20--0x23 "DECOB_LONG_BUFFER_HUNT_CHAR (at 0x90001320) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   HUNT_CHAR                      = "
  tree.end
  tree "DECOB_LONG_BUFFER_DEBUG_WR_ADDR"
   group.long 0x30--0x33 "DECOB_LONG_BUFFER_DEBUG_WR_ADDR (at 0x90001330)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DEBUG_WR_ADDR                  = "
  tree.end
  tree "DECOB_LONG_BUFFER_DEBUG_RD_ADDR"
   group.long 0x34--0x37 "DECOB_LONG_BUFFER_DEBUG_RD_ADDR (at 0x90001334)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   DEBUG_RD_ADDR                  = "
  tree.end
 tree "DECOB_PDCCH_0_DATA_RDm"
  tree "DECOB_PDCCH_0_DATA_RD0"
   group.long 0x40--0x43 "DECOB_PDCCH_0_DATA_RD0 (at 0x90001340)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
  tree "DECOB_PDCCH_0_DATA_RD1"
   group.long 0x44--0x47 "DECOB_PDCCH_0_DATA_RD1 (at 0x90001344)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
  tree "DECOB_PDCCH_0_DATA_RD2"
   group.long 0x48--0x4b "DECOB_PDCCH_0_DATA_RD2 (at 0x90001348)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
 tree.end
 tree "DECOB_PDCCH_1_DATA_RDm"
  tree "DECOB_PDCCH_1_DATA_RD0"
   group.long 0x4c--0x4f "DECOB_PDCCH_1_DATA_RD0 (at 0x9000134c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
  tree "DECOB_PDCCH_1_DATA_RD1"
   group.long 0x50--0x53 "DECOB_PDCCH_1_DATA_RD1 (at 0x90001350)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
  tree "DECOB_PDCCH_1_DATA_RD2"
   group.long 0x54--0x57 "DECOB_PDCCH_1_DATA_RD2 (at 0x90001354)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INNER_CRC                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MAC_ID                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   MESSAGE                        = "
  tree.end
 tree.end
 tree "DECOB_PDCCH_0_STATUS_RDm"
  tree "DECOB_PDCCH_0_STATUS_RD0"
   group.long 0x58--0x5b "DECOB_PDCCH_0_STATUS_RD0 (at 0x90001358)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "DECOB_PDCCH_0_STATUS_RD1"
   group.long 0x5c--0x5f "DECOB_PDCCH_0_STATUS_RD1 (at 0x9000135c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "DECOB_PDCCH_0_STATUS_RD2"
   group.long 0x60--0x63 "DECOB_PDCCH_0_STATUS_RD2 (at 0x90001360)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
 tree.end
 tree "DECOB_PDCCH_1_STATUS_RDm"
  tree "DECOB_PDCCH_1_STATUS_RD0"
   group.long 0x64--0x67 "DECOB_PDCCH_1_STATUS_RD0 (at 0x90001364)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "DECOB_PDCCH_1_STATUS_RD1"
   group.long 0x68--0x6b "DECOB_PDCCH_1_STATUS_RD1 (at 0x90001368)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "DECOB_PDCCH_1_STATUS_RD2"
   group.long 0x6c--0x6f "DECOB_PDCCH_1_STATUS_RD2 (at 0x9000136c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
 tree.end
 tree "DECOB_GCH_m_DATA_RD"
  tree "DECOB_GCH_0_DATA_RD"
   group.long 0x70--0x73 "DECOB_GCH_0_DATA_RD (at 0x90001370)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   DATA8_13                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA0_7                        = "
  tree.end
  tree "DECOB_GCH_1_DATA_RD"
   group.long 0x74--0x77 "DECOB_GCH_1_DATA_RD (at 0x90001374)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   DATA8_13                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA0_7                        = "
  tree.end
 tree.end
 tree "DECOB_GCH_m_STATUS_RD"
  tree "DECOB_GCH_0_STATUS_RD"
   group.long 0x78--0x7b "DECOB_GCH_0_STATUS_RD (at 0x90001378)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "DECOB_GCH_1_STATUS_RD"
   group.long 0x7c--0x7f "DECOB_GCH_1_STATUS_RD (at 0x9000137c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CRC_PASSING                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   SYMBOL_ERR_CNT                 = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   QUALITY                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   BAD_COUNT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VIOLATION                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   ENERGY_METRIC                  = "
  tree.end
 tree.end
  tree "DECOB_TEST_CTL"
   group.long 0x80--0x83 "DECOB_TEST_CTL (at 0x90001380) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   DBG_BUS_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MAC_ID_BYPASS                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SCRAMBLE_BYPASS                = " "0,1 "
  tree.end
  tree "DECOB_HW_CLK_CTL"
   group.long 0x84--0x87 "DECOB_HW_CLK_CTL (at 0x90001384)   (shadowed - Use hwio_shadow_ptr->DECOB_HW_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DECOB_HW_LCG_EN                = " "0,1 "
  tree.end
  tree "DECOB_MICRO_CLK_CTL"
   group.long 0x88--0x8b "DECOB_MICRO_CLK_CTL (at 0x90001388)   (shadowed - Use hwio_shadow_ptr->DECOB_MICRO_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   DECOB_MICRO_RD_CLK_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DECOB_MICRO_CLK_EN             = " "0,1 "
  tree.end
  tree "DECOB_CLK_STATUS"
   group.long 0x8c--0x8f "DECOB_CLK_STATUS (at 0x9000138c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DECOB_CLK_IS_OFF               = " "0,1 "
  tree.end
  tree "DECOB_CLK_SPARE_READ_REG0"
   group.long 0x90--0x93 "DECOB_CLK_SPARE_READ_REG0 (at 0x90001390) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DECOB_CLK_SPARE_READ_REG0      = "
  tree.end
tree.end

base ad:0x90003800
tree "DEINT"
  tree "DINT_RESET"
   group.long 0x0--0x3 "DINT_RESET (at 0x90003800)   (shadowed - Use hwio_shadow_ptr->DINT_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "DINT_CFG"
   group.long 0x4--0x7 "DINT_CFG (at 0x90003804)   (shadowed - Use hwio_shadow_ptr->DINT_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   L0_RAM_EXTEND                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   M0_RAM_EXTEND                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   L_UPPER_RAM_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   L_ODD_RAM_PAGE_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   M_UPPER_RAM_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   M_ODD_RAM_PAGE_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   N_UPPER_RAM_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   N_ODD_RAM_PAGE_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   P_UPPER_RAM_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   P_ODD_RAM_PAGE_SEL             = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   CHAN_RAM_ALLOC                 = "
  tree.end
 tree "DINT_CHw_CFG"
  tree "DINT_CH0_CFG"
   group.long 0x8--0xb "DINT_CH0_CFG (at 0x90003808)   (shadowed - Use hwio_shadow_ptr->DINT_CH0_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BCCH_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYNC26_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_CHAN_80M_BND              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   NEXT_20M_BND                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SEQUENCE_REP                   = " "0 (ONE_SEQUENCE_REPETITION),1 (TWO_SEQUENCES_REPEATED),2 (FOUR_SEQUENCE_REPETITION),3 (UNDEFINED_BIT) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NUM_SUB_CHANS                  = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "DINT_CH1_CFG"
   group.long 0xc--0xf "DINT_CH1_CFG (at 0x9000380c)   (shadowed - Use hwio_shadow_ptr->DINT_CH1_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BCCH_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYNC26_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_CHAN_80M_BND              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   NEXT_20M_BND                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SEQUENCE_REP                   = " "0 (ONE_SEQUENCE_REPETITION),1 (TWO_SEQUENCES_REPEATED),2 (FOUR_SEQUENCE_REPETITION),3 (UNDEFINED_BIT) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NUM_SUB_CHANS                  = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "DINT_CH2_CFG"
   group.long 0x10--0x13 "DINT_CH2_CFG (at 0x90003810)   (shadowed - Use hwio_shadow_ptr->DINT_CH2_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BCCH_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYNC26_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_CHAN_80M_BND              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   NEXT_20M_BND                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SEQUENCE_REP                   = " "0 (ONE_SEQUENCE_REPETITION),1 (TWO_SEQUENCES_REPEATED),2 (FOUR_SEQUENCE_REPETITION),3 (UNDEFINED_BIT) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NUM_SUB_CHANS                  = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "DINT_CH3_CFG"
   group.long 0x14--0x17 "DINT_CH3_CFG (at 0x90003814)   (shadowed - Use hwio_shadow_ptr->DINT_CH3_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BCCH_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYNC26_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_CHAN_80M_BND              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   NEXT_20M_BND                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SEQUENCE_REP                   = " "0 (ONE_SEQUENCE_REPETITION),1 (TWO_SEQUENCES_REPEATED),2 (FOUR_SEQUENCE_REPETITION),3 (UNDEFINED_BIT) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NUM_SUB_CHANS                  = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
  tree "TD_BLOCK_SIZE"
   group.long 0x18--0x1b "TD_BLOCK_SIZE (at 0x90003818)   (shadowed - Use hwio_shadow_ptr->TD_BLOCK_SIZE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "TD_INTLV_CFG_LO"
   group.long 0x1c--0x1f "TD_INTLV_CFG_LO (at 0x9000381c)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_CFG_LO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   ROW_WIDTH                      = " "0 (3_BIT_WIDE_ROW_INDEX),1 (4_BIT_WIDE_ROW_INDEX),2 (5_BIT_WIDE_ROW_INDEX),3 (6_BIT_WIDE_ROW_INDEX),4 (7_BIT_WIDE_ROW_INDEX),5 (8_BIT_WIDE_ROW_INDEX),6 (reserved),7 (CH3_IRAM1) "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   UNDEFINED_BITS12_0             = "
  tree.end
  tree "TD_INTLV_CFG_HI"
   group.long 0x20--0x23 "TD_INTLV_CFG_HI (at 0x90003820)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_CFG_HI to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INTLV_COLS                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INTLV_ROWS                     = "
  tree.end
  tree "TD_INTLV_SIZE_LO"
   group.long 0x24--0x27 "TD_INTLV_SIZE_LO (at 0x90003824)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_SIZE_LO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   EARLY_TERMINATION_EN           = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   UNDEFINED_BIT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TD_HYP_X1_ON                   = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TD_INTLV_LEN_X1                = "
  tree.end
  tree "TD_INTLV_SIZE_HI"
   group.long 0x28--0x2b "TD_INTLV_SIZE_HI (at 0x90003828)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_SIZE_HI to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   MAX_ITER_NUM                   = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   MIN_ITER_NUM                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   UNDEFINED_BITS3_0              = "
  tree.end
  tree "TD_PUNCT_LO"
   group.long 0x2c--0x2f "TD_PUNCT_LO (at 0x9000382c)   (shadowed - Use hwio_shadow_ptr->TD_PUNCT_LO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   PUNCT_PATTERN                  = "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   PUNCT_LENGTH                   = "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TD_DEC_INT_EN                  = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODE_RATE                      = " "0 (1_2_CODE_RATE),1 (1_3_CODE_RATE),2 (1_4_CODE_RATE),3 (UNDEFINED_BIT) "
  tree.end
  tree "TD_PUNCT_HI"
   group.long 0x30--0x33 "TD_PUNCT_HI (at 0x90003830)   (shadowed - Use hwio_shadow_ptr->TD_PUNCT_HI to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PUNCT_PATTERN                  = "
  tree.end
  tree "TD_PARAMS_LO"
   group.long 0x34--0x37 "TD_PARAMS_LO (at 0x90003834)   (shadowed - Use hwio_shadow_ptr->TD_PARAMS_LO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   FRM_20M_RATE_HYP               = " "0 (NO_RATE_HYPOTHESIS),1 (2_RATE_HYPOTHESES),2 (3_RATE_HYPOTHESES),3 (4_RATE_HYPOTHESES) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   SLIDE_WIN_LEN                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   PARTIAL_WIN_LENGTH             = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BETA_SELECT                    = "
  tree.end
  tree "TD_PARAMS_HI"
   group.long 0x38--0x3b "TD_PARAMS_HI (at 0x90003838)   (shadowed - Use hwio_shadow_ptr->TD_PARAMS_HI to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   MIN_NUM_CRC_PASS               = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   UNDEFINED_BITS9_8              = " "0,1,2,3 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_WINDOWS                    = "
  tree.end
  tree "DINT_PKT_OFFSET"
   group.long 0x3c--0x3f "DINT_PKT_OFFSET (at 0x9000383c)   (shadowed - Use hwio_shadow_ptr->DINT_PKT_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PACKET_OFFSET                  = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PACKET_TYPE                    = " "0 (reserved),1 (INTLV_CFG_HI),2 (BLK_SIZE_LO),3 (BLK_SIZE_HI),4 (PUNCT_LO),5 (PUNCT_HI),6 (PL_CRC_LO),7 (PL_CRC_HI) "
  tree.end
  tree "DINT_PKT_CFG"
   group.long 0x40--0x43 "DINT_PKT_CFG (at 0x90003840)   (shadowed - Use hwio_shadow_ptr->DINT_PKT_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   PAGE0_ROW_WIDTH                = " "0 (3_BIT_WIDE_ROW_INDEX),1 (4_BIT_WIDE_ROW_INDEX),2 (5_BIT_WIDE_ROW_INDEX),3 (6_BIT_WIDE_ROW_INDEX),4 (7_BIT_WIDE_ROW_INDEX),5 (8_BIT_WIDE_ROW_INDEX),6 (reserved),7 (PL_CRC_HI) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   PAGE0_CHAINBACK_DEPTH          = " "0 (CHAINBACK_DEPTH_OF_64),1 (CHAINBACK_DEPTH_OF_96) "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PAGE0_YM_THRESH                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   PAGE0_SMT_SCALAR               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   PAGE1_INTLV_COLS               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   PAGE1_UNDEFINED_BITS7_0        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PAGE2_FRAME_OR_PAGE_SIZE       = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   PAGE3_LTU_LEN                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   PAGE3_PUNCT_LENGTH             = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PAGE3_SYMBOL_REPEAT            = " "0 (SYMBOL_REPETITION_FACTOR_1),1 (SYMBOL_REPETITION_FACTOR_2),2 (SYMBOL_REPETITION_FACTOR_4),3 (SYMBOL_REPETITION_FACTOR_8) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PAGE3_CODE_RATE                = " "0 (1_2_CODE_RATE),1 (1_3_CODE_RATE),2 (1_4_CODE_RATE),3 (UNDEFINED_BIT) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   PAGE4_PUNCT_PATTERN            = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PAGE4_LTU_LEN_BITS             = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PAGE4_RDCNT_EN_SEL             = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PAGE4_NUM_LTU_FRM              = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PAGE5_PUNCT_PATTERN            = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PAGE6_PL_CRC                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PAGE7_LTU_CRC                  = "
  tree.end
  tree "DINT_TASK_OFFSET"
   group.long 0x44--0x47 "DINT_TASK_OFFSET (at 0x90003844)   (shadowed - Use hwio_shadow_ptr->DINT_TASK_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DATA1                          = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   DATA2                          = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA3                          = " "0,1 "
  tree.end
  tree "DINT_TASK_LIST"
   group.long 0x48--0x4b "DINT_TASK_LIST (at 0x90003848)   (shadowed - Use hwio_shadow_ptr->DINT_TASK_LIST to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   PAGE0_ACTIVE_TASK              = " "0 (DO_NOT_PERFORM_THIS_TASK),1 (PERFORM_THIS_TASK) "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PAGE0_SUB_CHANS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PAGE0_SYNC_CHAN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   PAGE0_DEC_INTR_EN              = " "0 (NO),1 (YES) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   PAGE0_CHAN_ID                  = " "0 (CH0),1 (CH1),2 (CH2),3 (CH3) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PAGE0_FRM_HYP                  = " "0 (5_MS_FRAME_HYP),1 (10_MS_FRAME_HYP),2 (20_MS_OR_LARGER_FRAME_HYP),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PAGE0_PACKET_OFFSET            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UNDEFINED_BIT3                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PAGE0_BIT_SHIFT                = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   PAGE1_RD_VD_LIN_ADDR           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   UNDEFINED_BITS14_12            = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   PAGE1_VD_OUTBUF_ADDR_OFFSET    = "
  tree.end
  tree "TST_SYNC_DINT"
   group.long 0x4c--0x4f "TST_SYNC_DINT (at 0x9000384c)   (shadowed - Use hwio_shadow_ptr->TST_SYNC_DINT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SYNC10                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   TD_SYNC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TD_DEINT_SYM1_REQ              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TD_DEINT_SYM0_REQ              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   TD_DEINT_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   TD_DEINT_ADDR_SKIP             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TD_DEINT_STROBE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TD_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   VD_SYNC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SYMS_ACK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   VD_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SYNC80                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC26                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC20                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC5                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_SLOT                      = " "0,1 "
  tree.end
  tree "TST_CH0_SYMS"
   group.long 0x50--0x53 "TST_CH0_SYMS (at 0x90003850)   (shadowed - Use hwio_shadow_ptr->TST_CH0_SYMS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   TST_CH0_RXSYM_Q                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TST_CH0_RXSYM_I                = "
  tree.end
  tree "TST_CH1_SYMS"
   group.long 0x54--0x57 "TST_CH1_SYMS (at 0x90003854)   (shadowed - Use hwio_shadow_ptr->TST_CH1_SYMS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   TST_CH1_RXSYM_Q                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TST_CH1_RXSYM_I                = "
  tree.end
  tree "TST_CH2_SYMS"
   group.long 0x58--0x5b "TST_CH2_SYMS (at 0x90003858)   (shadowed - Use hwio_shadow_ptr->TST_CH2_SYMS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   TST_CH2_RXSYM_Q                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TST_CH2_RXSYM_I                = "
  tree.end
  tree "TST_SEQ_PROC_PHASE"
   group.long 0x5c--0x5f "TST_SEQ_PROC_PHASE (at 0x9000385c)   (shadowed - Use hwio_shadow_ptr->TST_SEQ_PROC_PHASE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TST_SEQ_PHASE                  = " "0 (CH2),1 (CH3),2 (CH4),3 (CH5) "
  tree.end
  tree "TST_SEL_DINT"
   group.long 0x60--0x63 "TST_SEL_DINT (at 0x90003860)   (shadowed - Use hwio_shadow_ptr->TST_SEL_DINT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   GCH1_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   GCH0_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TST_SEL_PDCCH                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   PDCCH1_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PDCCH0_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TST_Q_CHAN_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TST_SEL_OB                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TST_SEL_TD                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TST_SEL_VD                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TST_SEL_DEM_LOC                = " "0,1 "
  tree.end
  tree "DINT_OTD_CFG"
   group.long 0x64--0x67 "DINT_OTD_CFG (at 0x90003864)   (shadowed - Use hwio_shadow_ptr->DINT_OTD_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OTD_SEL                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CH2_CODE_TYPE                  = " "0 (CONVOLUTIONALLY_ENCODED),1 (TURBO_ENCODED) "
  tree.end
  tree "TD_MIN_LLR_THRESH"
   group.long 0x68--0x6b "TD_MIN_LLR_THRESH (at 0x90003868)   (shadowed - Use hwio_shadow_ptr->TD_MIN_LLR_THRESH to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MIN_LLR_THRESH                 = "
  tree.end
  tree "TD_INTLV_LEN_X2"
   group.long 0x6c--0x6f "TD_INTLV_LEN_X2 (at 0x9000386c)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_LEN_X2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TD_HYP_X2_ON                   = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TD_INTLV_LEN_X2                = "
  tree.end
  tree "TD_INTLV_LEN_X4"
   group.long 0x70--0x73 "TD_INTLV_LEN_X4 (at 0x90003870)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_LEN_X4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TD_HYP_X4_ON                   = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TD_INTLV_LEN_X4                = "
  tree.end
  tree "TD_INTLV_LEN_X8"
   group.long 0x74--0x77 "TD_INTLV_LEN_X8 (at 0x90003874)   (shadowed - Use hwio_shadow_ptr->TD_INTLV_LEN_X8 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TD_HYP_X8_ON                   = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TD_INTLV_LEN_X8                = "
  tree.end
  tree "TD_NUM_SLWIN_X2"
   group.long 0x78--0x7b "TD_NUM_SLWIN_X2 (at 0x90003878)   (shadowed - Use hwio_shadow_ptr->TD_NUM_SLWIN_X2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "TD_NUM_SLWIN_X4"
   group.long 0x7c--0x7f "TD_NUM_SLWIN_X4 (at 0x9000387c)   (shadowed - Use hwio_shadow_ptr->TD_NUM_SLWIN_X4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "TD_NUM_SLWIN_X8"
   group.long 0x80--0x83 "TD_NUM_SLWIN_X8 (at 0x90003880)   (shadowed - Use hwio_shadow_ptr->TD_NUM_SLWIN_X8 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "DINT_GCH_CFG0"
   group.long 0x84--0x87 "DINT_GCH_CFG0 (at 0x90003884) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   INTLV_COLS                     = "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   GCH1_BIT_SHIFT                 = " "0 (NO_SHIFT),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (PL_CRC_HI) "
    textline ""
    bitfld.long 0x0 0x12--0x14 "  [20:18]   GCH0_BIT_SHIFT                 = " "0 (NO_SHIFT),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (PL_CRC_HI) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   GCH_DEC_INT_EN                 = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   ROW_WIDTH                      = " "0 (reserved),1 (reserved),2 (5_BIT_WIDE_ROW_INDEX),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (PL_CRC_HI) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   CHAINBACK_DEPTH                = " "0 (reserved),1 (CHAINBACK_DEPTH_OF_96) "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   YM_THRESH                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SMT_SCALAR                     = "
  tree.end
  tree "DINT_GCH_CFG1"
   group.long 0x88--0x8b "DINT_GCH_CFG1 (at 0x90003888) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   LTU_LEN                        = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x18 1 "  [24:20]   PUNCT_LENGTH                   = "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   SYMBOL_REPEAT                  = " "0 (SYMBOL_REPETITION_FACTOR_1),1 (reserved),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CODE_RATE                      = " "0 (1_2_CODE_RATE),1 (1_3_CODE_RATE),2 (1_4_CODE_RATE),3 (UNDEFINED_BIT) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FRAME_OR_PAGE_SIZE             = "
  tree.end
  tree "DINT_GCH_CFG2"
   group.long 0x8c--0x8f "DINT_GCH_CFG2 (at 0x9000388c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x8--0x1f 1 "  [31: 8]   PUNCT_PATTERN                  = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LTU_LEN_BITS                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   RDCNT_EN_SEL                   = " "0 (DON_T_CARE),1 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NUM_LTU_FRM                    = "
  tree.end
  tree "DINT_GCH_CFG3"
   group.long 0x90--0x93 "DINT_GCH_CFG3 (at 0x90003890) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   LTU_CRC                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PL_CRC                         = "
  tree.end
  tree "DINT_PDCCH_CFG"
   group.long 0x94--0x97 "DINT_PDCCH_CFG (at 0x90003894) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x15--0x1c 1 "  [28:21]   OUTER_CRC                      = "
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   PDCCH_BIT_SHIFT                = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   CHAINBACK_DEPTH                = " "0 (CHAINBACK_DEPTH_OF_64),1 (reserved) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PL_CRC                         = "
  tree.end
  tree "DINT_PDCCH_HYP0_CFG0"
   group.long 0x98--0x9b "DINT_PDCCH_HYP0_CFG0 (at 0x90003898) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INTLV_COLS                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   ROW_WIDTH                      = " "0 (reserved),1 (4_BIT_WIDE_ROW_INDEX),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (X_8_X_2_X_1_X_0) "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   YM_THRESH                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SMT_SCALAR                     = "
  tree.end
  tree "DINT_PDCCH_HYP1_CFG0"
   group.long 0x9c--0x9f "DINT_PDCCH_HYP1_CFG0 (at 0x9000389c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INTLV_COLS                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   ROW_WIDTH                      = " "0 (reserved),1 (reserved),2 (5_BIT_WIDE_ROW_INDEX),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (X_8_X_2_X_1_X_0) "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   YM_THRESH                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SMT_SCALAR                     = "
  tree.end
  tree "DINT_PDCCH_HYP2_CFG0"
   group.long 0xa0--0xa3 "DINT_PDCCH_HYP2_CFG0 (at 0x900038a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INTLV_COLS                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   ROW_WIDTH                      = " "0 (reserved),1 (reserved),2 (reserved),3 (6_BIT_WIDE_ROW_INDEX),4 (reserved),5 (reserved),6 (reserved),7 (X_8_X_2_X_1_X_0) "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RESERVED_BITS12                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   YM_THRESH                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SMT_SCALAR                     = "
  tree.end
  tree "DINT_PDCCH_HYP0_CFG1"
   group.long 0xa4--0xa7 "DINT_PDCCH_HYP0_CFG1 (at 0x900038a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   PUNCT_LENGTH                   = "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   SYMBOL_REPEAT                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CODE_RATE                      = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BLOCK_SIZE                     = "
  tree.end
  tree "DINT_PDCCH_HYP1_CFG1"
   group.long 0xa8--0xab "DINT_PDCCH_HYP1_CFG1 (at 0x900038a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   PUNCT_LENGTH                   = "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   SYMBOL_REPEAT                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CODE_RATE                      = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BLOCK_SIZE                     = "
  tree.end
  tree "DINT_PDCCH_HYP2_CFG1"
   group.long 0xac--0xaf "DINT_PDCCH_HYP2_CFG1 (at 0x900038ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1b 1 "  [27:20]   PUNCT_LENGTH                   = "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   SYMBOL_REPEAT                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CODE_RATE                      = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BLOCK_SIZE                     = "
  tree.end
  tree "DINT_TEST_MEM_SEL"
   group.long 0xb0--0xb3 "DINT_TEST_MEM_SEL (at 0x900038b0)   (shadowed - Use hwio_shadow_ptr->DINT_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DN_UP_N                        = " "0 (ADDRESS_INCREASE),1 (ADDRESS_DECREASE) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TST_EN_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TST_SEL_ALL                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RAM_SEL                        = "
  tree.end
  tree "DINT_TEST_MEM_ADDR"
   group.long 0xb4--0xb7 "DINT_TEST_MEM_ADDR (at 0x900038b4)   (shadowed - Use hwio_shadow_ptr->DINT_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TEST_MEM_ADDR                  = "
  tree.end
  tree "DINT_TEST_MEM_WRITE"
   group.long 0xb8--0xbb "DINT_TEST_MEM_WRITE (at 0x900038b8)   (shadowed - Use hwio_shadow_ptr->DINT_TEST_MEM_WRITE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TEST_MEM_WRITE                 = "
  tree.end
  tree "DINT_TEST_MEM_READ0"
   group.long 0xbc--0xbf "DINT_TEST_MEM_READ0 (at 0x900038bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TEST_MEM_READ0                 = "
  tree.end
  tree "TST_PDCCH_TASK"
   group.long 0xc0--0xc3 "TST_PDCCH_TASK (at 0x900038c0)   (shadowed - Use hwio_shadow_ptr->TST_PDCCH_TASK to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TST_PDCCH_INT_EN               = " "0,1 "
  tree.end
  tree "TST_SYS_TIME"
   group.long 0xc4--0xc7 "TST_SYS_TIME (at 0x900038c4)   (shadowed - Use hwio_shadow_ptr->TST_SYS_TIME to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   TST_SYS_TIME                   = "
  tree.end
  tree "DEINT_DBG_BUS_CTL"
   group.long 0xc8--0xcb "DEINT_DBG_BUS_CTL (at 0x900038c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DBG_MODE                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DBG_BUS_OUT_EN                 = " "0,1 "
  tree.end
  tree "DEINT_CLK_SPARE_READ_REG0"
   group.long 0xcc--0xcf "DEINT_CLK_SPARE_READ_REG0 (at 0x900038cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEINT_CLK_SPARE_READ_REG1"
   group.long 0xd0--0xd3 "DEINT_CLK_SPARE_READ_REG1 (at 0x900038d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEINT_HW_CLK_CTL"
   group.long 0xd4--0xd7 "DEINT_HW_CLK_CTL (at 0x900038d4)   (shadowed - Use hwio_shadow_ptr->DEINT_HW_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   HW_TASK_RD_LCG_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TD_RD_LCG_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HW_VD_RD_LCG_EN                = " "0,1 "
  tree.end
  tree "DEINT_MICRO_CLK_CTL"
   group.long 0xd8--0xdb "DEINT_MICRO_CLK_CTL (at 0x900038d8)   (shadowed - Use hwio_shadow_ptr->DEINT_MICRO_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MICRO_CLK_EN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MICRO_TASK_RD_CLK_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MICRO_TD_RD_CLK_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MICRO_VD_RD_CLK_EN             = " "0,1 "
  tree.end
  tree "DEINT_CLK_STATUS"
   group.long 0xdc--0xdf "DEINT_CLK_STATUS (at 0x900038dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DEINT_CLK_IS_OFF               = "
  tree.end
  tree "DEC_DONE_INT_STATUS"
   group.long 0xe0--0xe3 "DEC_DONE_INT_STATUS (at 0x900038e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PDCCH_TASK_DONE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   VD_DONE_STATUS                 = " "0 (TASK_NOT_YET_COMPLETED),1 (TASK_WAS_DONE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TD_DONE_STATUS                 = " "0 (TASK_NOT_YET_COMPLETED),1 (TASK_WAS_DONE) "
  tree.end
  tree "DEINT_TASK_STATUS"
   group.long 0x0--0x3 "DEINT_TASK_STATUS (at 0x90003800)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xb--0xf 1 "  [15:11]   UNDEFINED_BITS15_8             = "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   PDCCH1_DEC_DONE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PDCCH0_DEC_DONE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   GCH1_DEC_DONE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GCH0_DEC_DONE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   1X_DEC_DONE                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TASK_ID                        = "
  tree.end
  tree "DEINT_FRMHYP_STATUS"
   group.long 0x4--0x7 "DEINT_FRMHYP_STATUS (at 0x90003804)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   UNDEFINED_BITS                 = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   DATA1                          = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DATA2                          = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DATA3                          = "
  tree.end
  tree "DINT_VD_RD_ADDR"
   group.long 0x2c--0x2f "DINT_VD_RD_ADDR (at 0x9000382c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "DINT_TD_WR_ADDR"
   group.long 0x4c--0x4f "DINT_TD_WR_ADDR (at 0x9000384c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
tree.end
tree "DEMOD"
base ad:0x90000900
tree "DEMOD_1X_OFFLINE"
 tree "DEM1X_Fn_PILOT_IMMED"
  tree "DEM1X_F0_PILOT_IMMED"
   group.long 0x0--0x3 "DEM1X_F0_PILOT_IMMED (at 0x90000900) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F1_PILOT_IMMED"
   group.long 0x74--0x77 "DEM1X_F1_PILOT_IMMED (at 0x90000974) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F2_PILOT_IMMED"
   group.long 0xe8--0xeb "DEM1X_F2_PILOT_IMMED (at 0x900009e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F3_PILOT_IMMED"
   group.long 0x15c--0x15f "DEM1X_F3_PILOT_IMMED (at 0x90000a5c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F4_PILOT_IMMED"
   group.long 0x1d0--0x1d3 "DEM1X_F4_PILOT_IMMED (at 0x90000ad0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F5_PILOT_IMMED"
   group.long 0x244--0x247 "DEM1X_F5_PILOT_IMMED (at 0x90000b44) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F6_PILOT_IMMED"
   group.long 0x2b8--0x2bb "DEM1X_F6_PILOT_IMMED (at 0x90000bb8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
  tree "DEM1X_F7_PILOT_IMMED"
   group.long 0x32c--0x32f "DEM1X_F7_PILOT_IMMED (at 0x90000c2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   AUX_PILOT_ON                   = " "0 (COMMON),1 (AUXILIARY) "
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   PILOT_LEN                      = " "0 (64),1 (128),2 (256),3 (512) "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PILOT_PN_OFFSET                = "
  tree.end
 tree.end
 tree "DEM1X_Fn_DIVERSITY_IMMED"
  tree "DEM1X_F0_DIVERSITY_IMMED"
   group.long 0x4--0x7 "DEM1X_F0_DIVERSITY_IMMED (at 0x90000904) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F1_DIVERSITY_IMMED"
   group.long 0x78--0x7b "DEM1X_F1_DIVERSITY_IMMED (at 0x90000978) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F2_DIVERSITY_IMMED"
   group.long 0xec--0xef "DEM1X_F2_DIVERSITY_IMMED (at 0x900009ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F3_DIVERSITY_IMMED"
   group.long 0x160--0x163 "DEM1X_F3_DIVERSITY_IMMED (at 0x90000a60) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F4_DIVERSITY_IMMED"
   group.long 0x1d4--0x1d7 "DEM1X_F4_DIVERSITY_IMMED (at 0x90000ad4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F5_DIVERSITY_IMMED"
   group.long 0x248--0x24b "DEM1X_F5_DIVERSITY_IMMED (at 0x90000b48) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F6_DIVERSITY_IMMED"
   group.long 0x2bc--0x2bf "DEM1X_F6_DIVERSITY_IMMED (at 0x90000bbc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
  tree "DEM1X_F7_DIVERSITY_IMMED"
   group.long 0x330--0x333 "DEM1X_F7_DIVERSITY_IMMED (at 0x90000c30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MMSE_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PRIMARY_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV_MODE                       = " "0 (NONE),1 (RD),2 (TD_OTD),3 (TD_STS) "
  tree.end
 tree.end
 tree "DEM1X_Fn_WALSH_ACCm_IMMED"
 tree "DEM1X_F0_WALSH_ACCm_IMMED"
  tree "DEM1X_F0_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F0_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F0_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F0_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F0_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F0_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F0_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F0_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F0_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F0_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F0_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F0_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F0_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F0_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F0_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F1_WALSH_ACCm_IMMED"
  tree "DEM1X_F1_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F1_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F1_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F1_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F1_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F1_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F1_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F1_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F1_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F1_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F1_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F1_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F1_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F1_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F1_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F2_WALSH_ACCm_IMMED"
  tree "DEM1X_F2_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F2_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F2_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F2_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F2_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F2_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F2_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F2_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F2_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F2_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F2_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F2_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F2_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F2_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F2_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F3_WALSH_ACCm_IMMED"
  tree "DEM1X_F3_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F3_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F3_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F3_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F3_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F3_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F3_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F3_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F3_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F3_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F3_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F3_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F3_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F3_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F3_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F4_WALSH_ACCm_IMMED"
  tree "DEM1X_F4_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F4_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F4_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F4_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F4_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F4_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F4_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F4_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F4_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F4_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F4_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F4_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F4_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F4_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F4_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F5_WALSH_ACCm_IMMED"
  tree "DEM1X_F5_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F5_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F5_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F5_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F5_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F5_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F5_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F5_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F5_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F5_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F5_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F5_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F5_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F5_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F5_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F6_WALSH_ACCm_IMMED"
  tree "DEM1X_F6_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F6_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F6_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F6_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F6_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F6_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F6_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F6_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F6_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F6_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F6_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F6_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F6_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F6_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F6_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F7_WALSH_ACCm_IMMED"
  tree "DEM1X_F7_WALSH_ACC0_IMMED"
   group.long 0x8--0xb "DEM1X_F7_WALSH_ACC0_IMMED (at 0x90000908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC1_IMMED"
   group.long 0xc--0xf "DEM1X_F7_WALSH_ACC1_IMMED (at 0x9000090c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC2_IMMED"
   group.long 0x10--0x13 "DEM1X_F7_WALSH_ACC2_IMMED (at 0x90000910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC3_IMMED"
   group.long 0x14--0x17 "DEM1X_F7_WALSH_ACC3_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC4_IMMED"
   group.long 0x18--0x1b "DEM1X_F7_WALSH_ACC4_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC5_IMMED"
   group.long 0x1c--0x1f "DEM1X_F7_WALSH_ACC5_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC6_IMMED"
   group.long 0x20--0x23 "DEM1X_F7_WALSH_ACC6_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC7_IMMED"
   group.long 0x24--0x27 "DEM1X_F7_WALSH_ACC7_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC8_IMMED"
   group.long 0x28--0x2b "DEM1X_F7_WALSH_ACC8_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC9_IMMED"
   group.long 0x2c--0x2f "DEM1X_F7_WALSH_ACC9_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC10_IMMED"
   group.long 0x30--0x33 "DEM1X_F7_WALSH_ACC10_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC11_IMMED"
   group.long 0x34--0x37 "DEM1X_F7_WALSH_ACC11_IMMED (at 0x90000934) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC12_IMMED"
   group.long 0x38--0x3b "DEM1X_F7_WALSH_ACC12_IMMED (at 0x90000938) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC13_IMMED"
   group.long 0x3c--0x3f "DEM1X_F7_WALSH_ACC13_IMMED (at 0x9000093c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "DEM1X_Fn_WALSH_ACCm_FRAME"
 tree "DEM1X_F0_WALSH_ACCm_FRAME"
  tree "DEM1X_F0_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F0_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F0_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F0_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F0_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F0_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F0_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F0_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F0_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F0_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F0_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F0_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F0_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F0_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F0_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F1_WALSH_ACCm_FRAME"
  tree "DEM1X_F1_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F1_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F1_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F1_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F1_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F1_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F1_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F1_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F1_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F1_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F1_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F1_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F1_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F1_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F1_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F2_WALSH_ACCm_FRAME"
  tree "DEM1X_F2_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F2_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F2_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F2_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F2_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F2_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F2_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F2_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F2_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F2_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F2_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F2_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F2_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F2_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F2_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F3_WALSH_ACCm_FRAME"
  tree "DEM1X_F3_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F3_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F3_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F3_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F3_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F3_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F3_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F3_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F3_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F3_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F3_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F3_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F3_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F3_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F3_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F4_WALSH_ACCm_FRAME"
  tree "DEM1X_F4_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F4_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F4_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F4_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F4_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F4_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F4_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F4_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F4_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F4_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F4_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F4_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F4_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F4_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F4_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F5_WALSH_ACCm_FRAME"
  tree "DEM1X_F5_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F5_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F5_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F5_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F5_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F5_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F5_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F5_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F5_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F5_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F5_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F5_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F5_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F5_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F5_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F6_WALSH_ACCm_FRAME"
  tree "DEM1X_F6_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F6_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F6_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F6_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F6_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F6_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F6_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F6_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F6_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F6_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F6_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F6_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F6_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F6_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F6_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F7_WALSH_ACCm_FRAME"
  tree "DEM1X_F7_WALSH_ACC0_FRAME"
   group.long 0x408--0x40b "DEM1X_F7_WALSH_ACC0_FRAME (at 0x90000d08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC1_FRAME"
   group.long 0x40c--0x40f "DEM1X_F7_WALSH_ACC1_FRAME (at 0x90000d0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC2_FRAME"
   group.long 0x410--0x413 "DEM1X_F7_WALSH_ACC2_FRAME (at 0x90000d10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC3_FRAME"
   group.long 0x414--0x417 "DEM1X_F7_WALSH_ACC3_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC4_FRAME"
   group.long 0x418--0x41b "DEM1X_F7_WALSH_ACC4_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC5_FRAME"
   group.long 0x41c--0x41f "DEM1X_F7_WALSH_ACC5_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC6_FRAME"
   group.long 0x420--0x423 "DEM1X_F7_WALSH_ACC6_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC7_FRAME"
   group.long 0x424--0x427 "DEM1X_F7_WALSH_ACC7_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC8_FRAME"
   group.long 0x428--0x42b "DEM1X_F7_WALSH_ACC8_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC9_FRAME"
   group.long 0x42c--0x42f "DEM1X_F7_WALSH_ACC9_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC10_FRAME"
   group.long 0x430--0x433 "DEM1X_F7_WALSH_ACC10_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC11_FRAME"
   group.long 0x434--0x437 "DEM1X_F7_WALSH_ACC11_FRAME (at 0x90000d34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC12_FRAME"
   group.long 0x438--0x43b "DEM1X_F7_WALSH_ACC12_FRAME (at 0x90000d38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC13_FRAME"
   group.long 0x43c--0x43f "DEM1X_F7_WALSH_ACC13_FRAME (at 0x90000d3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH1_IMMED"
  tree "DEM1X_F0_HW_CH1_IMMED"
   group.long 0x40--0x43 "DEM1X_F0_HW_CH1_IMMED (at 0x90000940) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH1_IMMED"
   group.long 0xb4--0xb7 "DEM1X_F1_HW_CH1_IMMED (at 0x900009b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH1_IMMED"
   group.long 0x128--0x12b "DEM1X_F2_HW_CH1_IMMED (at 0x90000a28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH1_IMMED"
   group.long 0x19c--0x19f "DEM1X_F3_HW_CH1_IMMED (at 0x90000a9c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH1_IMMED"
   group.long 0x210--0x213 "DEM1X_F4_HW_CH1_IMMED (at 0x90000b10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH1_IMMED"
   group.long 0x284--0x287 "DEM1X_F5_HW_CH1_IMMED (at 0x90000b84) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH1_IMMED"
   group.long 0x2f8--0x2fb "DEM1X_F6_HW_CH1_IMMED (at 0x90000bf8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH1_IMMED"
   group.long 0x36c--0x36f "DEM1X_F7_HW_CH1_IMMED (at 0x90000c6c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH1_FRAME"
  tree "DEM1X_F0_HW_CH1_FRAME"
   group.long 0x440--0x443 "DEM1X_F0_HW_CH1_FRAME (at 0x90000d40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH1_FRAME"
   group.long 0x4b4--0x4b7 "DEM1X_F1_HW_CH1_FRAME (at 0x90000db4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH1_FRAME"
   group.long 0x528--0x52b "DEM1X_F2_HW_CH1_FRAME (at 0x90000e28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH1_FRAME"
   group.long 0x59c--0x59f "DEM1X_F3_HW_CH1_FRAME (at 0x90000e9c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH1_FRAME"
   group.long 0x610--0x613 "DEM1X_F4_HW_CH1_FRAME (at 0x90000f10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH1_FRAME"
   group.long 0x684--0x687 "DEM1X_F5_HW_CH1_FRAME (at 0x90000f84) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH1_FRAME"
   group.long 0x6f8--0x6fb "DEM1X_F6_HW_CH1_FRAME (at 0x90000ff8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH1_FRAME"
   group.long 0x76c--0x76f "DEM1X_F7_HW_CH1_FRAME (at 0x9000106c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   RESERVED_BITS11_8              = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH2_IMMED"
  tree "DEM1X_F0_HW_CH2_IMMED"
   group.long 0x44--0x47 "DEM1X_F0_HW_CH2_IMMED (at 0x90000944) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH2_IMMED"
   group.long 0xb8--0xbb "DEM1X_F1_HW_CH2_IMMED (at 0x900009b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH2_IMMED"
   group.long 0x12c--0x12f "DEM1X_F2_HW_CH2_IMMED (at 0x90000a2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH2_IMMED"
   group.long 0x1a0--0x1a3 "DEM1X_F3_HW_CH2_IMMED (at 0x90000aa0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH2_IMMED"
   group.long 0x214--0x217 "DEM1X_F4_HW_CH2_IMMED (at 0x90000b14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH2_IMMED"
   group.long 0x288--0x28b "DEM1X_F5_HW_CH2_IMMED (at 0x90000b88) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH2_IMMED"
   group.long 0x2fc--0x2ff "DEM1X_F6_HW_CH2_IMMED (at 0x90000bfc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH2_IMMED"
   group.long 0x370--0x373 "DEM1X_F7_HW_CH2_IMMED (at 0x90000c70) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH2_FRAME"
  tree "DEM1X_F0_HW_CH2_FRAME"
   group.long 0x444--0x447 "DEM1X_F0_HW_CH2_FRAME (at 0x90000d44) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH2_FRAME"
   group.long 0x4b8--0x4bb "DEM1X_F1_HW_CH2_FRAME (at 0x90000db8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH2_FRAME"
   group.long 0x52c--0x52f "DEM1X_F2_HW_CH2_FRAME (at 0x90000e2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH2_FRAME"
   group.long 0x5a0--0x5a3 "DEM1X_F3_HW_CH2_FRAME (at 0x90000ea0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH2_FRAME"
   group.long 0x614--0x617 "DEM1X_F4_HW_CH2_FRAME (at 0x90000f14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH2_FRAME"
   group.long 0x688--0x68b "DEM1X_F5_HW_CH2_FRAME (at 0x90000f88) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH2_FRAME"
   group.long 0x6fc--0x6ff "DEM1X_F6_HW_CH2_FRAME (at 0x90000ffc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH2_FRAME"
   group.long 0x770--0x773 "DEM1X_F7_HW_CH2_FRAME (at 0x90001070) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH3_IMMED"
  tree "DEM1X_F0_HW_CH3_IMMED"
   group.long 0x48--0x4b "DEM1X_F0_HW_CH3_IMMED (at 0x90000948) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH3_IMMED"
   group.long 0xbc--0xbf "DEM1X_F1_HW_CH3_IMMED (at 0x900009bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH3_IMMED"
   group.long 0x130--0x133 "DEM1X_F2_HW_CH3_IMMED (at 0x90000a30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH3_IMMED"
   group.long 0x1a4--0x1a7 "DEM1X_F3_HW_CH3_IMMED (at 0x90000aa4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH3_IMMED"
   group.long 0x218--0x21b "DEM1X_F4_HW_CH3_IMMED (at 0x90000b18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH3_IMMED"
   group.long 0x28c--0x28f "DEM1X_F5_HW_CH3_IMMED (at 0x90000b8c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH3_IMMED"
   group.long 0x300--0x303 "DEM1X_F6_HW_CH3_IMMED (at 0x90000c00) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH3_IMMED"
   group.long 0x374--0x377 "DEM1X_F7_HW_CH3_IMMED (at 0x90000c74) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH3_FRAME"
  tree "DEM1X_F0_HW_CH3_FRAME"
   group.long 0x448--0x44b "DEM1X_F0_HW_CH3_FRAME (at 0x90000d48) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH3_FRAME"
   group.long 0x4bc--0x4bf "DEM1X_F1_HW_CH3_FRAME (at 0x90000dbc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH3_FRAME"
   group.long 0x530--0x533 "DEM1X_F2_HW_CH3_FRAME (at 0x90000e30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH3_FRAME"
   group.long 0x5a4--0x5a7 "DEM1X_F3_HW_CH3_FRAME (at 0x90000ea4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH3_FRAME"
   group.long 0x618--0x61b "DEM1X_F4_HW_CH3_FRAME (at 0x90000f18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH3_FRAME"
   group.long 0x68c--0x68f "DEM1X_F5_HW_CH3_FRAME (at 0x90000f8c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH3_FRAME"
   group.long 0x700--0x703 "DEM1X_F6_HW_CH3_FRAME (at 0x90001000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH3_FRAME"
   group.long 0x774--0x777 "DEM1X_F7_HW_CH3_FRAME (at 0x90001074) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fa_WALSH_ACCb_IMMED"
 tree "DEM1X_F0_WALSH_ACCb_IMMED"
  tree "DEM1X_F0_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F0_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F0_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F0_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F0_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F0_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F0_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F0_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F0_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F1_WALSH_ACCb_IMMED"
  tree "DEM1X_F1_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F1_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F1_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F1_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F1_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F1_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F1_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F1_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F1_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F2_WALSH_ACCb_IMMED"
  tree "DEM1X_F2_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F2_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F2_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F2_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F2_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F2_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F2_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F2_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F2_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F3_WALSH_ACCb_IMMED"
  tree "DEM1X_F3_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F3_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F3_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F3_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F3_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F3_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F3_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F3_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F3_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F4_WALSH_ACCb_IMMED"
  tree "DEM1X_F4_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F4_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F4_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F4_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F4_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F4_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F4_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F4_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F4_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F5_WALSH_ACCb_IMMED"
  tree "DEM1X_F5_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F5_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F5_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F5_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F5_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F5_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F5_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F5_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F5_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F6_WALSH_ACCb_IMMED"
  tree "DEM1X_F6_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F6_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F6_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F6_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F6_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F6_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F6_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F6_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F6_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F7_WALSH_ACCb_IMMED"
  tree "DEM1X_F7_WALSH_ACC14_IMMED"
   group.long 0x14--0x17 "DEM1X_F7_WALSH_ACC14_IMMED (at 0x90000914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC15_IMMED"
   group.long 0x18--0x1b "DEM1X_F7_WALSH_ACC15_IMMED (at 0x90000918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC16_IMMED"
   group.long 0x1c--0x1f "DEM1X_F7_WALSH_ACC16_IMMED (at 0x9000091c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC17_IMMED"
   group.long 0x20--0x23 "DEM1X_F7_WALSH_ACC17_IMMED (at 0x90000920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC18_IMMED"
   group.long 0x24--0x27 "DEM1X_F7_WALSH_ACC18_IMMED (at 0x90000924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC19_IMMED"
   group.long 0x28--0x2b "DEM1X_F7_WALSH_ACC19_IMMED (at 0x90000928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC20_IMMED"
   group.long 0x2c--0x2f "DEM1X_F7_WALSH_ACC20_IMMED (at 0x9000092c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC21_IMMED"
   group.long 0x30--0x33 "DEM1X_F7_WALSH_ACC21_IMMED (at 0x90000930) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "DEM1X_Fa_WALSH_ACCb_FRAME"
 tree "DEM1X_F0_WALSH_ACCb_FRAME"
  tree "DEM1X_F0_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F0_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F0_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F0_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F0_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F0_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F0_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F0_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F0_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F0_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F1_WALSH_ACCb_FRAME"
  tree "DEM1X_F1_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F1_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F1_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F1_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F1_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F1_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F1_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F1_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F1_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F2_WALSH_ACCb_FRAME"
  tree "DEM1X_F2_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F2_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F2_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F2_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F2_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F2_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F2_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F2_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F2_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F3_WALSH_ACCb_FRAME"
  tree "DEM1X_F3_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F3_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F3_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F3_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F3_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F3_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F3_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F3_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F3_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F4_WALSH_ACCb_FRAME"
  tree "DEM1X_F4_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F4_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F4_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F4_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F4_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F4_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F4_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F4_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F4_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F5_WALSH_ACCb_FRAME"
  tree "DEM1X_F5_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F5_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F5_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F5_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F5_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F5_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F5_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F5_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F5_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F6_WALSH_ACCb_FRAME"
  tree "DEM1X_F6_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F6_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F6_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F6_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F6_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F6_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F6_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F6_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F6_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_F7_WALSH_ACCb_FRAME"
  tree "DEM1X_F7_WALSH_ACC14_FRAME"
   group.long 0x414--0x417 "DEM1X_F7_WALSH_ACC14_FRAME (at 0x90000d14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC15_FRAME"
   group.long 0x418--0x41b "DEM1X_F7_WALSH_ACC15_FRAME (at 0x90000d18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC16_FRAME"
   group.long 0x41c--0x41f "DEM1X_F7_WALSH_ACC16_FRAME (at 0x90000d1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC17_FRAME"
   group.long 0x420--0x423 "DEM1X_F7_WALSH_ACC17_FRAME (at 0x90000d20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC18_FRAME"
   group.long 0x424--0x427 "DEM1X_F7_WALSH_ACC18_FRAME (at 0x90000d24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC19_FRAME"
   group.long 0x428--0x42b "DEM1X_F7_WALSH_ACC19_FRAME (at 0x90000d28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC20_FRAME"
   group.long 0x42c--0x42f "DEM1X_F7_WALSH_ACC20_FRAME (at 0x90000d2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_WALSH_ACC21_FRAME"
   group.long 0x430--0x433 "DEM1X_F7_WALSH_ACC21_FRAME (at 0x90000d30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xb 1 "  [11: 3]   WALSH_CODE                     = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   QOF_SEL                        = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH4_IMMED"
  tree "DEM1X_F0_HW_CH4_IMMED"
   group.long 0x6c--0x6f "DEM1X_F0_HW_CH4_IMMED (at 0x9000096c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH4_IMMED"
   group.long 0xe0--0xe3 "DEM1X_F1_HW_CH4_IMMED (at 0x900009e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH4_IMMED"
   group.long 0x154--0x157 "DEM1X_F2_HW_CH4_IMMED (at 0x90000a54) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH4_IMMED"
   group.long 0x1c8--0x1cb "DEM1X_F3_HW_CH4_IMMED (at 0x90000ac8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH4_IMMED"
   group.long 0x23c--0x23f "DEM1X_F4_HW_CH4_IMMED (at 0x90000b3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH4_IMMED"
   group.long 0x2b0--0x2b3 "DEM1X_F5_HW_CH4_IMMED (at 0x90000bb0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH4_IMMED"
   group.long 0x324--0x327 "DEM1X_F6_HW_CH4_IMMED (at 0x90000c24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH4_IMMED"
   group.long 0x398--0x39b "DEM1X_F7_HW_CH4_IMMED (at 0x90000c98) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH4_FRAME"
  tree "DEM1X_F0_HW_CH4_FRAME"
   group.long 0x46c--0x46f "DEM1X_F0_HW_CH4_FRAME (at 0x90000d6c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH4_FRAME"
   group.long 0x4e0--0x4e3 "DEM1X_F1_HW_CH4_FRAME (at 0x90000de0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH4_FRAME"
   group.long 0x554--0x557 "DEM1X_F2_HW_CH4_FRAME (at 0x90000e54) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH4_FRAME"
   group.long 0x5c8--0x5cb "DEM1X_F3_HW_CH4_FRAME (at 0x90000ec8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH4_FRAME"
   group.long 0x63c--0x63f "DEM1X_F4_HW_CH4_FRAME (at 0x90000f3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH4_FRAME"
   group.long 0x6b0--0x6b3 "DEM1X_F5_HW_CH4_FRAME (at 0x90000fb0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH4_FRAME"
   group.long 0x724--0x727 "DEM1X_F6_HW_CH4_FRAME (at 0x90001024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH4_FRAME"
   group.long 0x798--0x79b "DEM1X_F7_HW_CH4_FRAME (at 0x90001098) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH5_IMMED"
  tree "DEM1X_F0_HW_CH5_IMMED"
   group.long 0x70--0x73 "DEM1X_F0_HW_CH5_IMMED (at 0x90000970) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH5_IMMED"
   group.long 0xe4--0xe7 "DEM1X_F1_HW_CH5_IMMED (at 0x900009e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH5_IMMED"
   group.long 0x158--0x15b "DEM1X_F2_HW_CH5_IMMED (at 0x90000a58) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH5_IMMED"
   group.long 0x1cc--0x1cf "DEM1X_F3_HW_CH5_IMMED (at 0x90000acc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH5_IMMED"
   group.long 0x240--0x243 "DEM1X_F4_HW_CH5_IMMED (at 0x90000b40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH5_IMMED"
   group.long 0x2b4--0x2b7 "DEM1X_F5_HW_CH5_IMMED (at 0x90000bb4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH5_IMMED"
   group.long 0x328--0x32b "DEM1X_F6_HW_CH5_IMMED (at 0x90000c28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH5_IMMED"
   group.long 0x39c--0x39f "DEM1X_F7_HW_CH5_IMMED (at 0x90000c9c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_Fn_HW_CH5_FRAME"
  tree "DEM1X_F0_HW_CH5_FRAME"
   group.long 0x470--0x473 "DEM1X_F0_HW_CH5_FRAME (at 0x90000d70) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F1_HW_CH5_FRAME"
   group.long 0x4e4--0x4e7 "DEM1X_F1_HW_CH5_FRAME (at 0x90000de4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F2_HW_CH5_FRAME"
   group.long 0x558--0x55b "DEM1X_F2_HW_CH5_FRAME (at 0x90000e58) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F3_HW_CH5_FRAME"
   group.long 0x5cc--0x5cf "DEM1X_F3_HW_CH5_FRAME (at 0x90000ecc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F4_HW_CH5_FRAME"
   group.long 0x640--0x643 "DEM1X_F4_HW_CH5_FRAME (at 0x90000f40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F5_HW_CH5_FRAME"
   group.long 0x6b4--0x6b7 "DEM1X_F5_HW_CH5_FRAME (at 0x90000fb4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F6_HW_CH5_FRAME"
   group.long 0x728--0x72b "DEM1X_F6_HW_CH5_FRAME (at 0x90001028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_F7_HW_CH5_FRAME"
   group.long 0x79c--0x79f "DEM1X_F7_HW_CH5_FRAME (at 0x9000109c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_8              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   RND                            = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SPR_MASK                       = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
  tree "DEM1X_FFE_TEST"
   group.long 0x3a0--0x3a3 "DEM1X_FFE_TEST (at 0x90000ca0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   QLIC_TEST_SEL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_DISABLE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PN_DISABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ROT_BYPASS                     = " "0,1 "
  tree.end
  tree "DEM1X_FFE_TEST_MODE"
   group.long 0x3a4--0x3a7 "DEM1X_FFE_TEST_MODE (at 0x90000ca4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MODE                           = "
  tree.end
  tree "DEM1X_FFE_TEST_MISR_RESET"
   group.long 0x3a8--0x3ab "DEM1X_FFE_TEST_MISR_RESET (at 0x90000ca8)   (shadowed - Use hwio_shadow_ptr->DEM1X_FFE_TEST_MISR_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "DEM1X_FFE_TEST_EXPORT_MISR"
   group.long 0x3ac--0x3af "DEM1X_FFE_TEST_EXPORT_MISR (at 0x90000cac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EXPORT                         = " "0 (reserved),1 (CURRENT_STATE_OF_THE_MISR) "
  tree.end
  tree "DEM1X_FFE_TEST_CAPTURED"
   group.long 0x3b0--0x3b3 "DEM1X_FFE_TEST_CAPTURED (at 0x90000cb0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CAPTURED                       = " "0,1 "
  tree.end
  tree "DEM1X_FFE_TEST_MISR_CURR_VAL"
   group.long 0x3b4--0x3b7 "DEM1X_FFE_TEST_MISR_CURR_VAL (at 0x90000cb4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "DEM1X_FFE_TEST_MISR_CAPT_VAL"
   group.long 0x3b8--0x3bb "DEM1X_FFE_TEST_MISR_CAPT_VAL (at 0x90000cb8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "DEM1X_TEST_MEM_SEL"
   group.long 0x3bc--0x3bf "DEM1X_TEST_MEM_SEL (at 0x90000cbc)   (shadowed - Use hwio_shadow_ptr->DEM1X_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DN_UP_N                        = " "0 (ADDRESS_INCREASE),1 (ADDRESS_DECREASE) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TST_EN_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TST_SEL_ALL                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RAM_SEL                        = "
  tree.end
  tree "DEM1X_TEST_MEM_ADDR"
   group.long 0x3c0--0x3c3 "DEM1X_TEST_MEM_ADDR (at 0x90000cc0)   (shadowed - Use hwio_shadow_ptr->DEM1X_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   TEST_MEM_ADDR                  = "
  tree.end
  tree "DEM1X_TEST_MEM_WRITE"
   group.long 0x3c4--0x3c7 "DEM1X_TEST_MEM_WRITE (at 0x90000cc4)   (shadowed - Use hwio_shadow_ptr->DEM1X_TEST_MEM_WRITE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_WRITE                 = "
  tree.end
  tree "DEM1X_TEST_MEM_READ0"
   group.long 0x3c8--0x3cb "DEM1X_TEST_MEM_READ0 (at 0x90000cc8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_READ0                 = "
  tree.end
  tree "DEM1X_HW_OFFLINE_CLK_CTL"
   group.long 0x3cc--0x3cf "DEM1X_HW_OFFLINE_CLK_CTL (at 0x90000ccc)   (shadowed - Use hwio_shadow_ptr->DEM1X_HW_OFFLINE_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   FFE_RESULT_LCG_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FFE_ENGINE_LCG_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FFE_CONFIG_LCG_EN              = " "0,1 "
  tree.end
  tree "DEM1X_MICRO_OFFLINE_CLK_CTL"
   group.long 0x3d0--0x3d3 "DEM1X_MICRO_OFFLINE_CLK_CTL (at 0x90000cd0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OFFLINE_CLK_OVERRIDE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   FFE_RESULT_CLK_OVERRIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FFE_ENGINE_CLK_OVERRIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FFE_CONFIG_CLK_OVERRIDE        = " "0,1 "
  tree.end
  tree "DEM1X_OFFLINE_CLK_STATUS"
   group.long 0x3d4--0x3d7 "DEM1X_OFFLINE_CLK_STATUS (at 0x90000cd4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OFFLINE_CLK_IS_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   FFE_RESULT_CLK_IS_OFF          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FFE_ENGINE_CLK_IS_OFF          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FFE_CONFIG_CLK_IS_OFF          = " "0,1 "
  tree.end
  tree "DEM1X_OFFLINE_SPARE_READ_REG0"
   group.long 0x3d8--0x3db "DEM1X_OFFLINE_SPARE_READ_REG0 (at 0x90000cd8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_OFFLINE_SPARE_READ_REG1"
   group.long 0x3dc--0x3df "DEM1X_OFFLINE_SPARE_READ_REG1 (at 0x90000cdc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_FFE_CONFIG_SPARE_READ_REG0"
   group.long 0x3e0--0x3e3 "DEM1X_FFE_CONFIG_SPARE_READ_REG0 (at 0x90000ce0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_FFE_RESULTS_SPARE_READ_REG0"
   group.long 0x3e4--0x3e7 "DEM1X_FFE_RESULTS_SPARE_READ_REG0 (at 0x90000ce4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_FFE_ENGINE_SPARE_READ_REG0"
   group.long 0x3e8--0x3eb "DEM1X_FFE_ENGINE_SPARE_READ_REG0 (at 0x90000ce8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_FFE_ENGINE_SPARE_READ_REG1"
   group.long 0x3ec--0x3ef "DEM1X_FFE_ENGINE_SPARE_READ_REG1 (at 0x90000cec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
tree.end

base ad:0x90000700
tree "DEMOD_1X_RXCHIPX8"
  tree "DEM1X_RESET"
   group.long 0x0--0x3 "DEM1X_RESET (at 0x90000700)   (shadowed - Use hwio_shadow_ptr->DEM1X_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "DEM1X_TRACKING"
   group.long 0xc--0xf "DEM1X_TRACKING (at 0x9000070c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   FINGER                         = " "0 (0),1 (1),2 (2),3 (3),4 (4),5 (5),6 (6),7 (7) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FRAME_OFFSET"
   group.long 0x10--0x13 "DEM1X_FRAME_OFFSET (at 0x90000710) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MODE                           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DATA                           = "
  tree.end
  tree "DEM1X_FINGER_MERGE"
   group.long 0x14--0x17 "DEM1X_FINGER_MERGE (at 0x90000714) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x4--0x12 1 "  [18: 4]   CHECK_EN                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   THRESH                         = "
  tree.end
 tree "DEM1X_FINGERn"
  tree "DEM1X_FINGER0"
   group.long 0x18--0x1b "DEM1X_FINGER0 (at 0x90000718) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER1"
   group.long 0x1c--0x1f "DEM1X_FINGER1 (at 0x9000071c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER2"
   group.long 0x20--0x23 "DEM1X_FINGER2 (at 0x90000720) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER3"
   group.long 0x24--0x27 "DEM1X_FINGER3 (at 0x90000724) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER4"
   group.long 0x28--0x2b "DEM1X_FINGER4 (at 0x90000728) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER5"
   group.long 0x2c--0x2f "DEM1X_FINGER5 (at 0x9000072c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER6"
   group.long 0x30--0x33 "DEM1X_FINGER6 (at 0x90000730) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FINGER7"
   group.long 0x34--0x37 "DEM1X_FINGER7 (at 0x90000734) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x12 1 "  [18: 1]   PN_POSITION                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
 tree.end
  tree "DEM1X_COMBINER_TIME_LOAD"
   group.long 0x38--0x3b "DEM1X_COMBINER_TIME_LOAD (at 0x90000738) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x1a 1 "  [26:20]   SYS_TIME                       = "
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   TIMECHIPX8                     = "
  tree.end
  tree "DEM1X_LC_STATE_LOAD_LO"
   group.long 0x48--0x4b "DEM1X_LC_STATE_LOAD_LO (at 0x90000748) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_LC_STATE_LOAD_HI"
   group.long 0x4c--0x4f "DEM1X_LC_STATE_LOAD_HI (at 0x9000074c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_COMBINER_TIME"
   group.long 0x54--0x57 "DEM1X_COMBINER_TIME (at 0x90000754)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1a 1 "  [26: 0]   LATCHED                        = "
  tree.end
  tree "DEM1X_FRAME_COUNT"
   group.long 0x58--0x5b "DEM1X_FRAME_COUNT (at 0x90000758)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   FRAME                          = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PCG                            = "
  tree.end
  tree "DEM1X_LC_STATE_LO"
   group.long 0x5c--0x5f "DEM1X_LC_STATE_LO (at 0x9000075c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   LATCHED                        = "
  tree.end
  tree "DEM1X_LC_STATE_HI"
   group.long 0x60--0x63 "DEM1X_LC_STATE_HI (at 0x90000760)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   LATCHED                        = "
  tree.end
  tree "DEM1X_TRAFFIC_REV_PWR_CTL"
   group.long 0x64--0x67 "DEM1X_TRAFFIC_REV_PWR_CTL (at 0x90000764) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   POWER_CTL_PCT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PUNC_POS_SEL                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PC_EVEN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERASE_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_COMMON_REV_PWR_CTL"
   group.long 0x68--0x6b "DEM1X_COMMON_REV_PWR_CTL (at 0x90000768) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   INIT_OFFSET4                   = "
    textline ""
    hexmask.long.byte 0x0 0x12--0x18 1 "  [24:18]   INIT_OFFSET3                   = "
    textline ""
    hexmask.long.byte 0x0 0xe--0x11 1 "  [17:14]   PC_RATE_SEL                    = "
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INIT_OFFSET2                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   INIT_OFFSET1                   = "
  tree.end
  tree "DEM1X_COMMON_REV_PWR_CTL2"
   group.long 0x6c--0x6f "DEM1X_COMMON_REV_PWR_CTL2 (at 0x9000076c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xe--0x13 1 "  [19:14]   VALID_SECTOR                   = "
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INIT_OFFSET6                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   INIT_OFFSET5                   = "
  tree.end
  tree "DEM1X_FWD_PWR_CTL_IMMED"
   group.long 0x70--0x73 "DEM1X_FWD_PWR_CTL_IMMED (at 0x90000770) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   WALSH_GAIN                     = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FPC_SEL                        = "
  tree.end
  tree "DEM1X_FWD_PWR_CTL_FRAME"
   group.long 0x74--0x77 "DEM1X_FWD_PWR_CTL_FRAME (at 0x90000774) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   WALSH_GAIN                     = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FPC_SEL                        = "
  tree.end
  tree "DEM1X_FWD_PWR_CTL_TIMING"
   group.long 0x78--0x7b "DEM1X_FWD_PWR_CTL_TIMING (at 0x90000778) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xf--0x13 1 "  [19:15]   SCH_POS_DSP                    = "
    textline ""
    hexmask.long.byte 0x0 0xa--0xe 1 "  [14:10]   SCH_POS                        = "
    textline ""
    hexmask.long.byte 0x0 0x5--0x9 1 "  [ 9: 5]   POS2                           = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   POS1                           = "
  tree.end
  tree "DEM1X_BETA_TIMING"
   group.long 0x7c--0x7f "DEM1X_BETA_TIMING (at 0x9000077c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x5--0x9 1 "  [ 9: 5]   BETA_POSITION2                 = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   BETA_POSITION1                 = "
  tree.end
  tree "DEM1X_TIME_INT1_ENABLE"
   group.long 0x84--0x87 "DEM1X_TIME_INT1_ENABLE (at 0x90000784) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT1_EN                   = "
  tree.end
  tree "DEM1X_TIME_INT1_STATUS"
   group.long 0x88--0x8b "DEM1X_TIME_INT1_STATUS (at 0x90000788)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT1_STATUS               = "
  tree.end
  tree "DEM1X_TIME_INT1_CLEAR"
   group.long 0x8c--0x8f "DEM1X_TIME_INT1_CLEAR (at 0x9000078c)   (shadowed - Use hwio_shadow_ptr->DEM1X_TIME_INT1_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT1_CLEAR                = "
  tree.end
  tree "DEM1X_TIME_INT2_ENABLE"
   group.long 0x90--0x93 "DEM1X_TIME_INT2_ENABLE (at 0x90000790) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT2_EN                   = "
  tree.end
  tree "DEM1X_TIME_INT2_STATUS"
   group.long 0x94--0x97 "DEM1X_TIME_INT2_STATUS (at 0x90000794)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT2_STATUS               = "
  tree.end
  tree "DEM1X_TIME_INT2_CLEAR"
   group.long 0x98--0x9b "DEM1X_TIME_INT2_CLEAR (at 0x90000798)   (shadowed - Use hwio_shadow_ptr->DEM1X_TIME_INT2_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_INT2_CLEAR                = "
  tree.end
 tree "DEM1X_CHn_LC_MASK_LO_IMMED"
  tree "DEM1X_CH0_LC_MASK_LO_IMMED"
   group.long 0x9c--0x9f "DEM1X_CH0_LC_MASK_LO_IMMED (at 0x9000079c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH1_LC_MASK_LO_IMMED"
   group.long 0xa4--0xa7 "DEM1X_CH1_LC_MASK_LO_IMMED (at 0x900007a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH2_LC_MASK_LO_IMMED"
   group.long 0xac--0xaf "DEM1X_CH2_LC_MASK_LO_IMMED (at 0x900007ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH3_LC_MASK_LO_IMMED"
   group.long 0xb4--0xb7 "DEM1X_CH3_LC_MASK_LO_IMMED (at 0x900007b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH4_LC_MASK_LO_IMMED"
   group.long 0xbc--0xbf "DEM1X_CH4_LC_MASK_LO_IMMED (at 0x900007bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH5_LC_MASK_LO_IMMED"
   group.long 0xc4--0xc7 "DEM1X_CH5_LC_MASK_LO_IMMED (at 0x900007c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH6_LC_MASK_LO_IMMED"
   group.long 0xcc--0xcf "DEM1X_CH6_LC_MASK_LO_IMMED (at 0x900007cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH7_LC_MASK_LO_IMMED"
   group.long 0xd4--0xd7 "DEM1X_CH7_LC_MASK_LO_IMMED (at 0x900007d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH8_LC_MASK_LO_IMMED"
   group.long 0xdc--0xdf "DEM1X_CH8_LC_MASK_LO_IMMED (at 0x900007dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree.end
 tree "DEM1X_CHn_LC_MASK_HI_IMMED"
  tree "DEM1X_CH0_LC_MASK_HI_IMMED"
   group.long 0xa0--0xa3 "DEM1X_CH0_LC_MASK_HI_IMMED (at 0x900007a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH1_LC_MASK_HI_IMMED"
   group.long 0xa8--0xab "DEM1X_CH1_LC_MASK_HI_IMMED (at 0x900007a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH2_LC_MASK_HI_IMMED"
   group.long 0xb0--0xb3 "DEM1X_CH2_LC_MASK_HI_IMMED (at 0x900007b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH3_LC_MASK_HI_IMMED"
   group.long 0xb8--0xbb "DEM1X_CH3_LC_MASK_HI_IMMED (at 0x900007b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH4_LC_MASK_HI_IMMED"
   group.long 0xc0--0xc3 "DEM1X_CH4_LC_MASK_HI_IMMED (at 0x900007c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH5_LC_MASK_HI_IMMED"
   group.long 0xc8--0xcb "DEM1X_CH5_LC_MASK_HI_IMMED (at 0x900007c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH6_LC_MASK_HI_IMMED"
   group.long 0xd0--0xd3 "DEM1X_CH6_LC_MASK_HI_IMMED (at 0x900007d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH7_LC_MASK_HI_IMMED"
   group.long 0xd8--0xdb "DEM1X_CH7_LC_MASK_HI_IMMED (at 0x900007d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH8_LC_MASK_HI_IMMED"
   group.long 0xe0--0xe3 "DEM1X_CH8_LC_MASK_HI_IMMED (at 0x900007e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "DEM1X_CHn_LC_MASK_LO_SPN_ROLL"
  tree "DEM1X_CH0_LC_MASK_LO_SPN_ROLL"
   group.long 0xe4--0xe7 "DEM1X_CH0_LC_MASK_LO_SPN_ROLL (at 0x900007e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH1_LC_MASK_LO_SPN_ROLL"
   group.long 0xec--0xef "DEM1X_CH1_LC_MASK_LO_SPN_ROLL (at 0x900007ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH2_LC_MASK_LO_SPN_ROLL"
   group.long 0xf4--0xf7 "DEM1X_CH2_LC_MASK_LO_SPN_ROLL (at 0x900007f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH3_LC_MASK_LO_SPN_ROLL"
   group.long 0xfc--0xff "DEM1X_CH3_LC_MASK_LO_SPN_ROLL (at 0x900007fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH4_LC_MASK_LO_SPN_ROLL"
   group.long 0x104--0x107 "DEM1X_CH4_LC_MASK_LO_SPN_ROLL (at 0x90000804) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH5_LC_MASK_LO_SPN_ROLL"
   group.long 0x10c--0x10f "DEM1X_CH5_LC_MASK_LO_SPN_ROLL (at 0x9000080c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH6_LC_MASK_LO_SPN_ROLL"
   group.long 0x114--0x117 "DEM1X_CH6_LC_MASK_LO_SPN_ROLL (at 0x90000814) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH7_LC_MASK_LO_SPN_ROLL"
   group.long 0x11c--0x11f "DEM1X_CH7_LC_MASK_LO_SPN_ROLL (at 0x9000081c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH8_LC_MASK_LO_SPN_ROLL"
   group.long 0x124--0x127 "DEM1X_CH8_LC_MASK_LO_SPN_ROLL (at 0x90000824) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree.end
 tree "DEM1X_CHn_LC_MASK_HI_SPN_ROLL"
  tree "DEM1X_CH0_LC_MASK_HI_SPN_ROLL"
   group.long 0xe8--0xeb "DEM1X_CH0_LC_MASK_HI_SPN_ROLL (at 0x900007e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH1_LC_MASK_HI_SPN_ROLL"
   group.long 0xf0--0xf3 "DEM1X_CH1_LC_MASK_HI_SPN_ROLL (at 0x900007f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH2_LC_MASK_HI_SPN_ROLL"
   group.long 0xf8--0xfb "DEM1X_CH2_LC_MASK_HI_SPN_ROLL (at 0x900007f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH3_LC_MASK_HI_SPN_ROLL"
   group.long 0x100--0x103 "DEM1X_CH3_LC_MASK_HI_SPN_ROLL (at 0x90000800) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH4_LC_MASK_HI_SPN_ROLL"
   group.long 0x108--0x10b "DEM1X_CH4_LC_MASK_HI_SPN_ROLL (at 0x90000808) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH5_LC_MASK_HI_SPN_ROLL"
   group.long 0x110--0x113 "DEM1X_CH5_LC_MASK_HI_SPN_ROLL (at 0x90000810) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH6_LC_MASK_HI_SPN_ROLL"
   group.long 0x118--0x11b "DEM1X_CH6_LC_MASK_HI_SPN_ROLL (at 0x90000818) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH7_LC_MASK_HI_SPN_ROLL"
   group.long 0x120--0x123 "DEM1X_CH7_LC_MASK_HI_SPN_ROLL (at 0x90000820) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "DEM1X_CH8_LC_MASK_HI_SPN_ROLL"
   group.long 0x128--0x12b "DEM1X_CH8_LC_MASK_HI_SPN_ROLL (at 0x90000828) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
  tree "DEM1X_COMBINER_CTL"
   group.long 0x12c--0x12f "DEM1X_COMBINER_CTL (at 0x9000082c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   PILOT_GATING_MASK              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FPC_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   FREQ_TRACK_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   Q_CHAN_OFF                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "DEM1X_FW_CH_ENABLE_IMMED"
   group.long 0x130--0x133 "DEM1X_FW_CH_ENABLE_IMMED (at 0x90000830) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ENABLE                         = "
  tree.end
  tree "DEM1X_FW_CH_ENABLE_FRAME"
   group.long 0x134--0x137 "DEM1X_FW_CH_ENABLE_FRAME (at 0x90000834) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ENABLE                         = "
  tree.end
  tree "DEM1X_CHANNEL0_IMMED"
   group.long 0x138--0x13b "DEM1X_CHANNEL0_IMMED (at 0x90000838) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   QP_I_ON                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   QP_Q_ON                        = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x12--0x1a 1 "  [26:18]   OOK_POSITION                   = "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   QPCH_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   CH0_DISABLE                    = " "0 (ENABLE),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RC4                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DCCH_ENABLE                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (SYMBOL_64_CHIP),1 (SYMBOL_128_CHIP),2 (SYMBOL_256_CHIP),3 (SYMBOL_512_CHIP) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL0_FRAME"
   group.long 0x13c--0x13f "DEM1X_CHANNEL0_FRAME (at 0x9000083c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RC4                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DCCH_ENABLE                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (SYMBOL_64_CHIP),1 (SYMBOL128_CHIP),2 (SYMBOL_256_CHIP),3 (SYMBOL_512_CHIP) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL1_IMMED"
   group.long 0x140--0x143 "DEM1X_CHANNEL1_IMMED (at 0x90000840) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (ROUND_OFF_8BITS) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DCCH_ENABLE                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (SYMBOL_64_CHIP),1 (SYMBOL_128_CHIP),2 (SYMBOL_256_CHIP),3 (SYMBOL_512_CHIP) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL1_FRAME"
   group.long 0x144--0x147 "DEM1X_CHANNEL1_FRAME (at 0x90000844) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (ROUND_OFF_8BITS) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DCCH_ENABLE                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (SYMBOL_64_CHIP),1 (SYMBOL_128_CHIP),2 (SYMBOL_256_CHIP),3 (SYMBOL_512_CHIP) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL2_IMMED"
   group.long 0x148--0x14b "DEM1X_CHANNEL2_IMMED (at 0x90000848) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1e "  [30:29]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (ROUND_OFF_8BITS) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PDCCH_1X_SEL                   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL2_FRAME"
   group.long 0x14c--0x14f "DEM1X_CHANNEL2_FRAME (at 0x9000084c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1e "  [30:29]   REP_FACTOR                     = " "0 (REP_1),1 (REP_2),2 (REP_4),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (ROUND_OFF_8BITS) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PDCCH_1X_SEL                   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL3_IMMED"
   group.long 0x150--0x153 "DEM1X_CHANNEL3_IMMED (at 0x90000850) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0 (NO_ROUNDING),1 (ROUND_OFF_1_BIT),2 (ROUND_OFF_2_BITS),3 (ROUND_OFF_3_BITS) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PDCCH_BCCH_SEL                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL3_FRAME"
   group.long 0x154--0x157 "DEM1X_CHANNEL3_FRAME (at 0x90000854) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x13--0x17 1 "  [23:19]   RESERVED_BITS23_19             = "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   SOFTDEC_ACCUM_RND              = " "0 (NO_ROUNDING),1 (ROUND_OFF_1_BIT),2 (ROUND_OFF_2_BITS),3 (ROUND_OFF_3_BITS) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PDCCH_BCCH_SEL                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL4_IMMED"
   group.long 0x158--0x15b "DEM1X_CHANNEL4_IMMED (at 0x90000858) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1d 1 "  [29:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x11--0x17 1 "  [23:17]   RESERVED_BITS23_17             = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL4_FRAME"
   group.long 0x15c--0x15f "DEM1X_CHANNEL4_FRAME (at 0x9000085c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1d 1 "  [29:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x11--0x17 1 "  [23:17]   RESERVED_BITS23_17             = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL5_IMMED"
   group.long 0x160--0x163 "DEM1X_CHANNEL5_IMMED (at 0x90000860) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1d 1 "  [29:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x11--0x17 1 "  [23:17]   RESERVED_BITS23_17             = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL5_FRAME"
   group.long 0x164--0x167 "DEM1X_CHANNEL5_FRAME (at 0x90000864) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1d 1 "  [29:24]   SPR_MASK                       = "
    textline ""
    hexmask.long.byte 0x0 0x11--0x17 1 "  [23:17]   RESERVED_BITS23_17             = "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   SOFTDEC_RND                    = " "0 (ROUND_OFF_10_BITS),1 (reserved) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   HW_EN                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   RESERVED_BITS14_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SW_BETA                        = "
  tree.end
  tree "DEM1X_CHANNEL6_IMMED"
   group.long 0x168--0x16b "DEM1X_CHANNEL6_IMMED (at 0x90000868) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   RCCH_EN                        = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xe 1 "  [14:10]   RESERVED_BITS14_10             = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (reserved),1 (SYMBOL_128_CHIP),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BITS7_0               = "
  tree.end
  tree "DEM1X_CHANNEL6_FRAME"
   group.long 0x16c--0x16f "DEM1X_CHANNEL6_FRAME (at 0x9000086c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   RCCH_EN                        = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xe 1 "  [14:10]   RESERVED_BITS14_10             = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (reserved),1 (SYMBOL_128_CHIP),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BITS7_0               = "
  tree.end
  tree "DEM1X_CHANNEL8_IMMED"
   group.long 0x170--0x173 "DEM1X_CHANNEL8_IMMED (at 0x90000870) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   CPCCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RESERVED_BITS14                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (reserved),1 (SYMBOL_128_CHIP),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BITS7_0               = "
  tree.end
  tree "DEM1X_CHANNEL8_FRAME"
   group.long 0x174--0x177 "DEM1X_CHANNEL8_FRAME (at 0x90000874) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   CPCCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RESERVED_BITS14                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xa--0xd 1 "  [13:10]   TD_SIGN                        = "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RATE_SEL                       = " "0 (reserved),1 (SYMBOL_128_CHIP),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BITS7_0               = "
  tree.end
 tree "DEM1X_ACKCH_FINGERn_IMMED"
  tree "DEM1X_ACKCH_FINGER0_IMMED"
   group.long 0x178--0x17b "DEM1X_ACKCH_FINGER0_IMMED (at 0x90000878) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_ACKCH_FINGER1_IMMED"
   group.long 0x17c--0x17f "DEM1X_ACKCH_FINGER1_IMMED (at 0x9000087c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_ACKCH_FINGER2_IMMED"
   group.long 0x180--0x183 "DEM1X_ACKCH_FINGER2_IMMED (at 0x90000880) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_ACKCH_FINGER3_IMMED"
   group.long 0x184--0x187 "DEM1X_ACKCH_FINGER3_IMMED (at 0x90000884) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_ACKCH_FINGER4_IMMED"
   group.long 0x188--0x18b "DEM1X_ACKCH_FINGER4_IMMED (at 0x90000888) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
  tree "DEM1X_ACKCH_FINGER5_IMMED"
   group.long 0x18c--0x18f "DEM1X_ACKCH_FINGER5_IMMED (at 0x9000088c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACKCH_EN                       = " "0,1 "
  tree.end
 tree.end
 tree "DEM1X_ACKCH_FINGERn_FRAME"
  tree "DEM1X_ACKCH_FINGER0_FRAME"
   group.long 0x190--0x193 "DEM1X_ACKCH_FINGER0_FRAME (at 0x90000890) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "DEM1X_ACKCH_FINGER1_FRAME"
   group.long 0x194--0x197 "DEM1X_ACKCH_FINGER1_FRAME (at 0x90000894) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "DEM1X_ACKCH_FINGER2_FRAME"
   group.long 0x198--0x19b "DEM1X_ACKCH_FINGER2_FRAME (at 0x90000898) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "DEM1X_ACKCH_FINGER3_FRAME"
   group.long 0x19c--0x19f "DEM1X_ACKCH_FINGER3_FRAME (at 0x9000089c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "DEM1X_ACKCH_FINGER4_FRAME"
   group.long 0x1a0--0x1a3 "DEM1X_ACKCH_FINGER4_FRAME (at 0x900008a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "DEM1X_ACKCH_FINGER5_FRAME"
   group.long 0x1a4--0x1a7 "DEM1X_ACKCH_FINGER5_FRAME (at 0x900008a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   CODE_INDEX                     = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SLOT_PHASE                     = " "0 (FIRST_1_67MS),1 (SECOND_1_67_MS),2 (THIRD_1_67_MS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   IQ_CHAN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ACKCH_EN                       = " "0 (DISABLE),1 (ENABLE) "
  tree.end
 tree.end
  tree "DEM1X_RCCH_CTL"
   group.long 0x1a8--0x1ab "DEM1X_RCCH_CTL (at 0x900008a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   INIT_OFFSET4                   = "
    textline ""
    hexmask.long.byte 0x0 0x12--0x18 1 "  [24:18]   INIT_OFFSET3                   = "
    textline ""
    hexmask.long.byte 0x0 0xe--0x11 1 "  [17:14]   RC_RATE_SEL                    = "
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INIT_OFFSET2                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   INIT_OFFSET1                   = "
  tree.end
  tree "DEM1X_RCCH_CTL2"
   group.long 0x1ac--0x1af "DEM1X_RCCH_CTL2 (at 0x900008ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xe--0x13 1 "  [19:14]   VALID_SECTOR                   = "
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INIT_OFFSET6                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   INIT_OFFSET5                   = "
  tree.end
  tree "DEM1X_SYS_TIME_GP_COMPARE"
   group.long 0x1b0--0x1b3 "DEM1X_SYS_TIME_GP_COMPARE (at 0x900008b0)   (shadowed - Use hwio_shadow_ptr->DEM1X_SYS_TIME_GP_COMPARE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GP_INT_EN                      = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1a 1 "  [26: 0]   SYS_TIME_GP_COMPARE            = "
  tree.end
  tree "DEM1X_OFFLINE"
   group.long 0x1b4--0x1b7 "DEM1X_OFFLINE (at 0x900008b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   ENABLE                         = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xf--0x1d 1 "  [29:15]   START_VAL                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   STOP_VAL                       = "
  tree.end
  tree "DEM1X_REF_COUNT"
   group.long 0x1b8--0x1bb "DEM1X_REF_COUNT (at 0x900008b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   LATCHED                        = "
  tree.end
  tree "DEM1X_RTC_ADJUST"
   group.long 0x1bc--0x1bf "DEM1X_RTC_ADJUST (at 0x900008bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SYM_DLY                        = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "DEM1X_RTF_CTL_SEL"
   group.long 0x1c0--0x1c3 "DEM1X_RTF_CTL_SEL (at 0x900008c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   IMMED_EN                       = " "0 (TAKE_EFFECT_AT_THE_NEXT_COMBINE_SYMBOL_BOUNDARY),1 (TAKE_EFFECT_IMMEDIATELY) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CTL_SEL                        = " "0 (ARM),1 (MDSP) "
  tree.end
  tree "DEM1X_LPN_ADV"
   group.long 0x1c4--0x1c7 "DEM1X_LPN_ADV (at 0x900008c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SYM_ADV                        = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "DEM1X_FINGER_MERGE_F8"
   group.long 0x1c8--0x1cb "DEM1X_FINGER_MERGE_F8 (at 0x900008c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x4--0x1f 1 "  [31: 4]   CHECK_EN                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   THRESH                         = "
  tree.end
  tree "DEM1X_CX8_TEST_MODE"
   group.long 0x1cc--0x1cf "DEM1X_CX8_TEST_MODE (at 0x900008cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE                           = "
  tree.end
  tree "DEM1X_CX8_TEST_MISR_RESET"
   group.long 0x1d0--0x1d3 "DEM1X_CX8_TEST_MISR_RESET (at 0x900008d0)   (shadowed - Use hwio_shadow_ptr->DEM1X_CX8_TEST_MISR_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "DEM1X_CX8_TEST_EXPORT_MISR"
   group.long 0x1d4--0x1d7 "DEM1X_CX8_TEST_EXPORT_MISR (at 0x900008d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EXPORT                         = " "0 (VALUE_SENT_INTO_MISR),1 (CURRENT_STATE_OF_MISR) "
  tree.end
  tree "DEM1X_CX8_TEST_CAPTURED"
   group.long 0x1d8--0x1db "DEM1X_CX8_TEST_CAPTURED (at 0x900008d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CAPTURED                       = " "0,1 "
  tree.end
  tree "DEM1X_CX8_TEST_MISR_CURR_VAL"
   group.long 0x1dc--0x1df "DEM1X_CX8_TEST_MISR_CURR_VAL (at 0x900008dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "DEM1X_CX8_TEST_MISR_CAPT_VAL"
   group.long 0x1e0--0x1e3 "DEM1X_CX8_TEST_MISR_CAPT_VAL (at 0x900008e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "DEM1X_MICRO_CX8_CLK_CTL"
   group.long 0x1e4--0x1e7 "DEM1X_MICRO_CX8_CLK_CTL (at 0x900008e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CX8_CLK_OVERRIDE               = " "0,1 "
  tree.end
  tree "DEM1X_CX8_CLK_STATUS"
   group.long 0x1e8--0x1eb "DEM1X_CX8_CLK_STATUS (at 0x900008e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CX8_CLK_IS_OFF                 = " "0,1 "
  tree.end
  tree "DEM1X_RXCX8_SPARE_READ_REG0"
   group.long 0x1ec--0x1ef "DEM1X_RXCX8_SPARE_READ_REG0 (at 0x900008ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_RXCX8_SPARE_READ_REG1"
   group.long 0x1f0--0x1f3 "DEM1X_RXCX8_SPARE_READ_REG1 (at 0x900008f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_RXCX8_SPARE_READ_REG2"
   group.long 0x1f4--0x1f7 "DEM1X_RXCX8_SPARE_READ_REG2 (at 0x900008f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_RXCX8_SPARE_READ_REG3"
   group.long 0x1f8--0x1fb "DEM1X_RXCX8_SPARE_READ_REG3 (at 0x900008f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "DEM1X_RXCX8WR_SPARE_READ_REG0"
   group.long 0x1fc--0x1ff "DEM1X_RXCX8WR_SPARE_READ_REG0 (at 0x900008fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
tree.end
tree.end

base ad:0x90400000
tree "DMH00"
 tree "MDM_HI0_CHn_CMD_PTR_SDs"
 tree "MDM_HI0_CH0_CMD_PTR_SDs"
  tree "MDM_HI0_CH0_CMD_PTR_SD0"
   group.long 0x0--0x3 "MDM_HI0_CH0_CMD_PTR_SD0 (at 0x90400000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH0_CMD_PTR_SD1"
   group.long 0x400--0x403 "MDM_HI0_CH0_CMD_PTR_SD1 (at 0x90400400)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH0_CMD_PTR_SD2"
   group.long 0x800--0x803 "MDM_HI0_CH0_CMD_PTR_SD2 (at 0x90400800)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH0_CMD_PTR_SD3"
   group.long 0xc00--0xc03 "MDM_HI0_CH0_CMD_PTR_SD3 (at 0x90400c00)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_CMD_PTR_SDs"
  tree "MDM_HI0_CH1_CMD_PTR_SD0"
   group.long 0x4--0x7 "MDM_HI0_CH1_CMD_PTR_SD0 (at 0x90400004)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH1_CMD_PTR_SD1"
   group.long 0x404--0x407 "MDM_HI0_CH1_CMD_PTR_SD1 (at 0x90400404)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH1_CMD_PTR_SD2"
   group.long 0x804--0x807 "MDM_HI0_CH1_CMD_PTR_SD2 (at 0x90400804)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH1_CMD_PTR_SD3"
   group.long 0xc04--0xc07 "MDM_HI0_CH1_CMD_PTR_SD3 (at 0x90400c04)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_CMD_PTR_SDs"
  tree "MDM_HI0_CH2_CMD_PTR_SD0"
   group.long 0x8--0xb "MDM_HI0_CH2_CMD_PTR_SD0 (at 0x90400008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH2_CMD_PTR_SD1"
   group.long 0x408--0x40b "MDM_HI0_CH2_CMD_PTR_SD1 (at 0x90400408)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH2_CMD_PTR_SD2"
   group.long 0x808--0x80b "MDM_HI0_CH2_CMD_PTR_SD2 (at 0x90400808)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH2_CMD_PTR_SD3"
   group.long 0xc08--0xc0b "MDM_HI0_CH2_CMD_PTR_SD3 (at 0x90400c08)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_CMD_PTR_SDs"
  tree "MDM_HI0_CH3_CMD_PTR_SD0"
   group.long 0xc--0xf "MDM_HI0_CH3_CMD_PTR_SD0 (at 0x9040000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH3_CMD_PTR_SD1"
   group.long 0x40c--0x40f "MDM_HI0_CH3_CMD_PTR_SD1 (at 0x9040040c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH3_CMD_PTR_SD2"
   group.long 0x80c--0x80f "MDM_HI0_CH3_CMD_PTR_SD2 (at 0x9040080c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH3_CMD_PTR_SD3"
   group.long 0xc0c--0xc0f "MDM_HI0_CH3_CMD_PTR_SD3 (at 0x90400c0c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_CMD_PTR_SDs"
  tree "MDM_HI0_CH4_CMD_PTR_SD0"
   group.long 0x10--0x13 "MDM_HI0_CH4_CMD_PTR_SD0 (at 0x90400010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH4_CMD_PTR_SD1"
   group.long 0x410--0x413 "MDM_HI0_CH4_CMD_PTR_SD1 (at 0x90400410)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH4_CMD_PTR_SD2"
   group.long 0x810--0x813 "MDM_HI0_CH4_CMD_PTR_SD2 (at 0x90400810)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH4_CMD_PTR_SD3"
   group.long 0xc10--0xc13 "MDM_HI0_CH4_CMD_PTR_SD3 (at 0x90400c10)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_CMD_PTR_SDs"
  tree "MDM_HI0_CH5_CMD_PTR_SD0"
   group.long 0x14--0x17 "MDM_HI0_CH5_CMD_PTR_SD0 (at 0x90400014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH5_CMD_PTR_SD1"
   group.long 0x414--0x417 "MDM_HI0_CH5_CMD_PTR_SD1 (at 0x90400414)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH5_CMD_PTR_SD2"
   group.long 0x814--0x817 "MDM_HI0_CH5_CMD_PTR_SD2 (at 0x90400814)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH5_CMD_PTR_SD3"
   group.long 0xc14--0xc17 "MDM_HI0_CH5_CMD_PTR_SD3 (at 0x90400c14)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_CMD_PTR_SDs"
  tree "MDM_HI0_CH6_CMD_PTR_SD0"
   group.long 0x18--0x1b "MDM_HI0_CH6_CMD_PTR_SD0 (at 0x90400018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH6_CMD_PTR_SD1"
   group.long 0x418--0x41b "MDM_HI0_CH6_CMD_PTR_SD1 (at 0x90400418)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH6_CMD_PTR_SD2"
   group.long 0x818--0x81b "MDM_HI0_CH6_CMD_PTR_SD2 (at 0x90400818)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH6_CMD_PTR_SD3"
   group.long 0xc18--0xc1b "MDM_HI0_CH6_CMD_PTR_SD3 (at 0x90400c18)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_CMD_PTR_SDs"
  tree "MDM_HI0_CH7_CMD_PTR_SD0"
   group.long 0x1c--0x1f "MDM_HI0_CH7_CMD_PTR_SD0 (at 0x9040001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH7_CMD_PTR_SD1"
   group.long 0x41c--0x41f "MDM_HI0_CH7_CMD_PTR_SD1 (at 0x9040041c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH7_CMD_PTR_SD2"
   group.long 0x81c--0x81f "MDM_HI0_CH7_CMD_PTR_SD2 (at 0x9040081c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH7_CMD_PTR_SD3"
   group.long 0xc1c--0xc1f "MDM_HI0_CH7_CMD_PTR_SD3 (at 0x90400c1c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_CMD_PTR_SDs"
  tree "MDM_HI0_CH8_CMD_PTR_SD0"
   group.long 0x20--0x23 "MDM_HI0_CH8_CMD_PTR_SD0 (at 0x90400020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH8_CMD_PTR_SD1"
   group.long 0x420--0x423 "MDM_HI0_CH8_CMD_PTR_SD1 (at 0x90400420)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH8_CMD_PTR_SD2"
   group.long 0x820--0x823 "MDM_HI0_CH8_CMD_PTR_SD2 (at 0x90400820)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH8_CMD_PTR_SD3"
   group.long 0xc20--0xc23 "MDM_HI0_CH8_CMD_PTR_SD3 (at 0x90400c20)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_CMD_PTR_SDs"
  tree "MDM_HI0_CH9_CMD_PTR_SD0"
   group.long 0x24--0x27 "MDM_HI0_CH9_CMD_PTR_SD0 (at 0x90400024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH9_CMD_PTR_SD1"
   group.long 0x424--0x427 "MDM_HI0_CH9_CMD_PTR_SD1 (at 0x90400424)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH9_CMD_PTR_SD2"
   group.long 0x824--0x827 "MDM_HI0_CH9_CMD_PTR_SD2 (at 0x90400824)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH9_CMD_PTR_SD3"
   group.long 0xc24--0xc27 "MDM_HI0_CH9_CMD_PTR_SD3 (at 0x90400c24)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_CMD_PTR_SDs"
  tree "MDM_HI0_CH10_CMD_PTR_SD0"
   group.long 0x28--0x2b "MDM_HI0_CH10_CMD_PTR_SD0 (at 0x90400028)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH10_CMD_PTR_SD1"
   group.long 0x428--0x42b "MDM_HI0_CH10_CMD_PTR_SD1 (at 0x90400428)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH10_CMD_PTR_SD2"
   group.long 0x828--0x82b "MDM_HI0_CH10_CMD_PTR_SD2 (at 0x90400828)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH10_CMD_PTR_SD3"
   group.long 0xc28--0xc2b "MDM_HI0_CH10_CMD_PTR_SD3 (at 0x90400c28)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_CMD_PTR_SDs"
  tree "MDM_HI0_CH11_CMD_PTR_SD0"
   group.long 0x2c--0x2f "MDM_HI0_CH11_CMD_PTR_SD0 (at 0x9040002c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH11_CMD_PTR_SD1"
   group.long 0x42c--0x42f "MDM_HI0_CH11_CMD_PTR_SD1 (at 0x9040042c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH11_CMD_PTR_SD2"
   group.long 0x82c--0x82f "MDM_HI0_CH11_CMD_PTR_SD2 (at 0x9040082c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH11_CMD_PTR_SD3"
   group.long 0xc2c--0xc2f "MDM_HI0_CH11_CMD_PTR_SD3 (at 0x90400c2c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_CMD_PTR_SDs"
  tree "MDM_HI0_CH12_CMD_PTR_SD0"
   group.long 0x30--0x33 "MDM_HI0_CH12_CMD_PTR_SD0 (at 0x90400030)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH12_CMD_PTR_SD1"
   group.long 0x430--0x433 "MDM_HI0_CH12_CMD_PTR_SD1 (at 0x90400430)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH12_CMD_PTR_SD2"
   group.long 0x830--0x833 "MDM_HI0_CH12_CMD_PTR_SD2 (at 0x90400830)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH12_CMD_PTR_SD3"
   group.long 0xc30--0xc33 "MDM_HI0_CH12_CMD_PTR_SD3 (at 0x90400c30)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_CMD_PTR_SDs"
  tree "MDM_HI0_CH13_CMD_PTR_SD0"
   group.long 0x34--0x37 "MDM_HI0_CH13_CMD_PTR_SD0 (at 0x90400034)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH13_CMD_PTR_SD1"
   group.long 0x434--0x437 "MDM_HI0_CH13_CMD_PTR_SD1 (at 0x90400434)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH13_CMD_PTR_SD2"
   group.long 0x834--0x837 "MDM_HI0_CH13_CMD_PTR_SD2 (at 0x90400834)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH13_CMD_PTR_SD3"
   group.long 0xc34--0xc37 "MDM_HI0_CH13_CMD_PTR_SD3 (at 0x90400c34)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_CMD_PTR_SDs"
  tree "MDM_HI0_CH14_CMD_PTR_SD0"
   group.long 0x38--0x3b "MDM_HI0_CH14_CMD_PTR_SD0 (at 0x90400038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH14_CMD_PTR_SD1"
   group.long 0x438--0x43b "MDM_HI0_CH14_CMD_PTR_SD1 (at 0x90400438)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH14_CMD_PTR_SD2"
   group.long 0x838--0x83b "MDM_HI0_CH14_CMD_PTR_SD2 (at 0x90400838)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH14_CMD_PTR_SD3"
   group.long 0xc38--0xc3b "MDM_HI0_CH14_CMD_PTR_SD3 (at 0x90400c38)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_CMD_PTR_SDs"
  tree "MDM_HI0_CH15_CMD_PTR_SD0"
   group.long 0x3c--0x3f "MDM_HI0_CH15_CMD_PTR_SD0 (at 0x9040003c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH15_CMD_PTR_SD1"
   group.long 0x43c--0x43f "MDM_HI0_CH15_CMD_PTR_SD1 (at 0x9040043c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH15_CMD_PTR_SD2"
   group.long 0x83c--0x83f "MDM_HI0_CH15_CMD_PTR_SD2 (at 0x9040083c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
  tree "MDM_HI0_CH15_CMD_PTR_SD3"
   group.long 0xc3c--0xc3f "MDM_HI0_CH15_CMD_PTR_SD3 (at 0x90400c3c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_BITS31_29             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   ADDR                           = "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_RSLT_SDs"
 tree "MDM_HI0_CH0_RSLT_SDs"
  tree "MDM_HI0_CH0_RSLT_SD0"
   group.long 0x40--0x43 "MDM_HI0_CH0_RSLT_SD0 (at 0x90400040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_SD1"
   group.long 0x440--0x443 "MDM_HI0_CH0_RSLT_SD1 (at 0x90400440) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_SD2"
   group.long 0x840--0x843 "MDM_HI0_CH0_RSLT_SD2 (at 0x90400840) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_SD3"
   group.long 0xc40--0xc43 "MDM_HI0_CH0_RSLT_SD3 (at 0x90400c40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_RSLT_SDs"
  tree "MDM_HI0_CH1_RSLT_SD0"
   group.long 0x44--0x47 "MDM_HI0_CH1_RSLT_SD0 (at 0x90400044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_SD1"
   group.long 0x444--0x447 "MDM_HI0_CH1_RSLT_SD1 (at 0x90400444) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_SD2"
   group.long 0x844--0x847 "MDM_HI0_CH1_RSLT_SD2 (at 0x90400844) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_SD3"
   group.long 0xc44--0xc47 "MDM_HI0_CH1_RSLT_SD3 (at 0x90400c44) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_RSLT_SDs"
  tree "MDM_HI0_CH2_RSLT_SD0"
   group.long 0x48--0x4b "MDM_HI0_CH2_RSLT_SD0 (at 0x90400048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_SD1"
   group.long 0x448--0x44b "MDM_HI0_CH2_RSLT_SD1 (at 0x90400448) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_SD2"
   group.long 0x848--0x84b "MDM_HI0_CH2_RSLT_SD2 (at 0x90400848) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_SD3"
   group.long 0xc48--0xc4b "MDM_HI0_CH2_RSLT_SD3 (at 0x90400c48) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_RSLT_SDs"
  tree "MDM_HI0_CH3_RSLT_SD0"
   group.long 0x4c--0x4f "MDM_HI0_CH3_RSLT_SD0 (at 0x9040004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_SD1"
   group.long 0x44c--0x44f "MDM_HI0_CH3_RSLT_SD1 (at 0x9040044c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_SD2"
   group.long 0x84c--0x84f "MDM_HI0_CH3_RSLT_SD2 (at 0x9040084c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_SD3"
   group.long 0xc4c--0xc4f "MDM_HI0_CH3_RSLT_SD3 (at 0x90400c4c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_RSLT_SDs"
  tree "MDM_HI0_CH4_RSLT_SD0"
   group.long 0x50--0x53 "MDM_HI0_CH4_RSLT_SD0 (at 0x90400050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_SD1"
   group.long 0x450--0x453 "MDM_HI0_CH4_RSLT_SD1 (at 0x90400450) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_SD2"
   group.long 0x850--0x853 "MDM_HI0_CH4_RSLT_SD2 (at 0x90400850) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_SD3"
   group.long 0xc50--0xc53 "MDM_HI0_CH4_RSLT_SD3 (at 0x90400c50) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_RSLT_SDs"
  tree "MDM_HI0_CH5_RSLT_SD0"
   group.long 0x54--0x57 "MDM_HI0_CH5_RSLT_SD0 (at 0x90400054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_SD1"
   group.long 0x454--0x457 "MDM_HI0_CH5_RSLT_SD1 (at 0x90400454) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_SD2"
   group.long 0x854--0x857 "MDM_HI0_CH5_RSLT_SD2 (at 0x90400854) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_SD3"
   group.long 0xc54--0xc57 "MDM_HI0_CH5_RSLT_SD3 (at 0x90400c54) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_RSLT_SDs"
  tree "MDM_HI0_CH6_RSLT_SD0"
   group.long 0x58--0x5b "MDM_HI0_CH6_RSLT_SD0 (at 0x90400058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_SD1"
   group.long 0x458--0x45b "MDM_HI0_CH6_RSLT_SD1 (at 0x90400458) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_SD2"
   group.long 0x858--0x85b "MDM_HI0_CH6_RSLT_SD2 (at 0x90400858) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_SD3"
   group.long 0xc58--0xc5b "MDM_HI0_CH6_RSLT_SD3 (at 0x90400c58) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_RSLT_SDs"
  tree "MDM_HI0_CH7_RSLT_SD0"
   group.long 0x5c--0x5f "MDM_HI0_CH7_RSLT_SD0 (at 0x9040005c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_SD1"
   group.long 0x45c--0x45f "MDM_HI0_CH7_RSLT_SD1 (at 0x9040045c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_SD2"
   group.long 0x85c--0x85f "MDM_HI0_CH7_RSLT_SD2 (at 0x9040085c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_SD3"
   group.long 0xc5c--0xc5f "MDM_HI0_CH7_RSLT_SD3 (at 0x90400c5c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_RSLT_SDs"
  tree "MDM_HI0_CH8_RSLT_SD0"
   group.long 0x60--0x63 "MDM_HI0_CH8_RSLT_SD0 (at 0x90400060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_SD1"
   group.long 0x460--0x463 "MDM_HI0_CH8_RSLT_SD1 (at 0x90400460) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_SD2"
   group.long 0x860--0x863 "MDM_HI0_CH8_RSLT_SD2 (at 0x90400860) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_SD3"
   group.long 0xc60--0xc63 "MDM_HI0_CH8_RSLT_SD3 (at 0x90400c60) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_RSLT_SDs"
  tree "MDM_HI0_CH9_RSLT_SD0"
   group.long 0x64--0x67 "MDM_HI0_CH9_RSLT_SD0 (at 0x90400064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_SD1"
   group.long 0x464--0x467 "MDM_HI0_CH9_RSLT_SD1 (at 0x90400464) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_SD2"
   group.long 0x864--0x867 "MDM_HI0_CH9_RSLT_SD2 (at 0x90400864) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_SD3"
   group.long 0xc64--0xc67 "MDM_HI0_CH9_RSLT_SD3 (at 0x90400c64) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_RSLT_SDs"
  tree "MDM_HI0_CH10_RSLT_SD0"
   group.long 0x68--0x6b "MDM_HI0_CH10_RSLT_SD0 (at 0x90400068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_SD1"
   group.long 0x468--0x46b "MDM_HI0_CH10_RSLT_SD1 (at 0x90400468) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_SD2"
   group.long 0x868--0x86b "MDM_HI0_CH10_RSLT_SD2 (at 0x90400868) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_SD3"
   group.long 0xc68--0xc6b "MDM_HI0_CH10_RSLT_SD3 (at 0x90400c68) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_RSLT_SDs"
  tree "MDM_HI0_CH11_RSLT_SD0"
   group.long 0x6c--0x6f "MDM_HI0_CH11_RSLT_SD0 (at 0x9040006c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_SD1"
   group.long 0x46c--0x46f "MDM_HI0_CH11_RSLT_SD1 (at 0x9040046c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_SD2"
   group.long 0x86c--0x86f "MDM_HI0_CH11_RSLT_SD2 (at 0x9040086c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_SD3"
   group.long 0xc6c--0xc6f "MDM_HI0_CH11_RSLT_SD3 (at 0x90400c6c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_RSLT_SDs"
  tree "MDM_HI0_CH12_RSLT_SD0"
   group.long 0x70--0x73 "MDM_HI0_CH12_RSLT_SD0 (at 0x90400070) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_SD1"
   group.long 0x470--0x473 "MDM_HI0_CH12_RSLT_SD1 (at 0x90400470) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_SD2"
   group.long 0x870--0x873 "MDM_HI0_CH12_RSLT_SD2 (at 0x90400870) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_SD3"
   group.long 0xc70--0xc73 "MDM_HI0_CH12_RSLT_SD3 (at 0x90400c70) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_RSLT_SDs"
  tree "MDM_HI0_CH13_RSLT_SD0"
   group.long 0x74--0x77 "MDM_HI0_CH13_RSLT_SD0 (at 0x90400074) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_SD1"
   group.long 0x474--0x477 "MDM_HI0_CH13_RSLT_SD1 (at 0x90400474) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_SD2"
   group.long 0x874--0x877 "MDM_HI0_CH13_RSLT_SD2 (at 0x90400874) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_SD3"
   group.long 0xc74--0xc77 "MDM_HI0_CH13_RSLT_SD3 (at 0x90400c74) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_RSLT_SDs"
  tree "MDM_HI0_CH14_RSLT_SD0"
   group.long 0x78--0x7b "MDM_HI0_CH14_RSLT_SD0 (at 0x90400078) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_SD1"
   group.long 0x478--0x47b "MDM_HI0_CH14_RSLT_SD1 (at 0x90400478) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_SD2"
   group.long 0x878--0x87b "MDM_HI0_CH14_RSLT_SD2 (at 0x90400878) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_SD3"
   group.long 0xc78--0xc7b "MDM_HI0_CH14_RSLT_SD3 (at 0x90400c78) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_RSLT_SDs"
  tree "MDM_HI0_CH15_RSLT_SD0"
   group.long 0x7c--0x7f "MDM_HI0_CH15_RSLT_SD0 (at 0x9040007c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_SD1"
   group.long 0x47c--0x47f "MDM_HI0_CH15_RSLT_SD1 (at 0x9040047c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_SD2"
   group.long 0x87c--0x87f "MDM_HI0_CH15_RSLT_SD2 (at 0x9040087c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_SD3"
   group.long 0xc7c--0xc7f "MDM_HI0_CH15_RSLT_SD3 (at 0x90400c7c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   V                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ERR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   F                              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TPD                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE0_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE0_SD0"
   group.long 0x80--0x83 "MDM_HI0_CH0_FLUSH_STATE0_SD0 (at 0x90400080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE0_SD1"
   group.long 0x480--0x483 "MDM_HI0_CH0_FLUSH_STATE0_SD1 (at 0x90400480)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE0_SD2"
   group.long 0x880--0x883 "MDM_HI0_CH0_FLUSH_STATE0_SD2 (at 0x90400880)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE0_SD3"
   group.long 0xc80--0xc83 "MDM_HI0_CH0_FLUSH_STATE0_SD3 (at 0x90400c80)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE0_SD0"
   group.long 0x84--0x87 "MDM_HI0_CH1_FLUSH_STATE0_SD0 (at 0x90400084)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE0_SD1"
   group.long 0x484--0x487 "MDM_HI0_CH1_FLUSH_STATE0_SD1 (at 0x90400484)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE0_SD2"
   group.long 0x884--0x887 "MDM_HI0_CH1_FLUSH_STATE0_SD2 (at 0x90400884)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE0_SD3"
   group.long 0xc84--0xc87 "MDM_HI0_CH1_FLUSH_STATE0_SD3 (at 0x90400c84)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE0_SD0"
   group.long 0x88--0x8b "MDM_HI0_CH2_FLUSH_STATE0_SD0 (at 0x90400088)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE0_SD1"
   group.long 0x488--0x48b "MDM_HI0_CH2_FLUSH_STATE0_SD1 (at 0x90400488)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE0_SD2"
   group.long 0x888--0x88b "MDM_HI0_CH2_FLUSH_STATE0_SD2 (at 0x90400888)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE0_SD3"
   group.long 0xc88--0xc8b "MDM_HI0_CH2_FLUSH_STATE0_SD3 (at 0x90400c88)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE0_SD0"
   group.long 0x8c--0x8f "MDM_HI0_CH3_FLUSH_STATE0_SD0 (at 0x9040008c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE0_SD1"
   group.long 0x48c--0x48f "MDM_HI0_CH3_FLUSH_STATE0_SD1 (at 0x9040048c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE0_SD2"
   group.long 0x88c--0x88f "MDM_HI0_CH3_FLUSH_STATE0_SD2 (at 0x9040088c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE0_SD3"
   group.long 0xc8c--0xc8f "MDM_HI0_CH3_FLUSH_STATE0_SD3 (at 0x90400c8c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE0_SD0"
   group.long 0x90--0x93 "MDM_HI0_CH4_FLUSH_STATE0_SD0 (at 0x90400090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE0_SD1"
   group.long 0x490--0x493 "MDM_HI0_CH4_FLUSH_STATE0_SD1 (at 0x90400490)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE0_SD2"
   group.long 0x890--0x893 "MDM_HI0_CH4_FLUSH_STATE0_SD2 (at 0x90400890)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE0_SD3"
   group.long 0xc90--0xc93 "MDM_HI0_CH4_FLUSH_STATE0_SD3 (at 0x90400c90)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE0_SD0"
   group.long 0x94--0x97 "MDM_HI0_CH5_FLUSH_STATE0_SD0 (at 0x90400094)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE0_SD1"
   group.long 0x494--0x497 "MDM_HI0_CH5_FLUSH_STATE0_SD1 (at 0x90400494)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE0_SD2"
   group.long 0x894--0x897 "MDM_HI0_CH5_FLUSH_STATE0_SD2 (at 0x90400894)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE0_SD3"
   group.long 0xc94--0xc97 "MDM_HI0_CH5_FLUSH_STATE0_SD3 (at 0x90400c94)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE0_SD0"
   group.long 0x98--0x9b "MDM_HI0_CH6_FLUSH_STATE0_SD0 (at 0x90400098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE0_SD1"
   group.long 0x498--0x49b "MDM_HI0_CH6_FLUSH_STATE0_SD1 (at 0x90400498)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE0_SD2"
   group.long 0x898--0x89b "MDM_HI0_CH6_FLUSH_STATE0_SD2 (at 0x90400898)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE0_SD3"
   group.long 0xc98--0xc9b "MDM_HI0_CH6_FLUSH_STATE0_SD3 (at 0x90400c98)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE0_SD0"
   group.long 0x9c--0x9f "MDM_HI0_CH7_FLUSH_STATE0_SD0 (at 0x9040009c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE0_SD1"
   group.long 0x49c--0x49f "MDM_HI0_CH7_FLUSH_STATE0_SD1 (at 0x9040049c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE0_SD2"
   group.long 0x89c--0x89f "MDM_HI0_CH7_FLUSH_STATE0_SD2 (at 0x9040089c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE0_SD3"
   group.long 0xc9c--0xc9f "MDM_HI0_CH7_FLUSH_STATE0_SD3 (at 0x90400c9c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE0_SD0"
   group.long 0xa0--0xa3 "MDM_HI0_CH8_FLUSH_STATE0_SD0 (at 0x904000a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE0_SD1"
   group.long 0x4a0--0x4a3 "MDM_HI0_CH8_FLUSH_STATE0_SD1 (at 0x904004a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE0_SD2"
   group.long 0x8a0--0x8a3 "MDM_HI0_CH8_FLUSH_STATE0_SD2 (at 0x904008a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE0_SD3"
   group.long 0xca0--0xca3 "MDM_HI0_CH8_FLUSH_STATE0_SD3 (at 0x90400ca0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE0_SD0"
   group.long 0xa4--0xa7 "MDM_HI0_CH9_FLUSH_STATE0_SD0 (at 0x904000a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE0_SD1"
   group.long 0x4a4--0x4a7 "MDM_HI0_CH9_FLUSH_STATE0_SD1 (at 0x904004a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE0_SD2"
   group.long 0x8a4--0x8a7 "MDM_HI0_CH9_FLUSH_STATE0_SD2 (at 0x904008a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE0_SD3"
   group.long 0xca4--0xca7 "MDM_HI0_CH9_FLUSH_STATE0_SD3 (at 0x90400ca4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE0_SD0"
   group.long 0xa8--0xab "MDM_HI0_CH10_FLUSH_STATE0_SD0 (at 0x904000a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE0_SD1"
   group.long 0x4a8--0x4ab "MDM_HI0_CH10_FLUSH_STATE0_SD1 (at 0x904004a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE0_SD2"
   group.long 0x8a8--0x8ab "MDM_HI0_CH10_FLUSH_STATE0_SD2 (at 0x904008a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE0_SD3"
   group.long 0xca8--0xcab "MDM_HI0_CH10_FLUSH_STATE0_SD3 (at 0x90400ca8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE0_SD0"
   group.long 0xac--0xaf "MDM_HI0_CH11_FLUSH_STATE0_SD0 (at 0x904000ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE0_SD1"
   group.long 0x4ac--0x4af "MDM_HI0_CH11_FLUSH_STATE0_SD1 (at 0x904004ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE0_SD2"
   group.long 0x8ac--0x8af "MDM_HI0_CH11_FLUSH_STATE0_SD2 (at 0x904008ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE0_SD3"
   group.long 0xcac--0xcaf "MDM_HI0_CH11_FLUSH_STATE0_SD3 (at 0x90400cac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE0_SD0"
   group.long 0xb0--0xb3 "MDM_HI0_CH12_FLUSH_STATE0_SD0 (at 0x904000b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE0_SD1"
   group.long 0x4b0--0x4b3 "MDM_HI0_CH12_FLUSH_STATE0_SD1 (at 0x904004b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE0_SD2"
   group.long 0x8b0--0x8b3 "MDM_HI0_CH12_FLUSH_STATE0_SD2 (at 0x904008b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE0_SD3"
   group.long 0xcb0--0xcb3 "MDM_HI0_CH12_FLUSH_STATE0_SD3 (at 0x90400cb0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE0_SD0"
   group.long 0xb4--0xb7 "MDM_HI0_CH13_FLUSH_STATE0_SD0 (at 0x904000b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE0_SD1"
   group.long 0x4b4--0x4b7 "MDM_HI0_CH13_FLUSH_STATE0_SD1 (at 0x904004b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE0_SD2"
   group.long 0x8b4--0x8b7 "MDM_HI0_CH13_FLUSH_STATE0_SD2 (at 0x904008b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE0_SD3"
   group.long 0xcb4--0xcb7 "MDM_HI0_CH13_FLUSH_STATE0_SD3 (at 0x90400cb4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE0_SD0"
   group.long 0xb8--0xbb "MDM_HI0_CH14_FLUSH_STATE0_SD0 (at 0x904000b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE0_SD1"
   group.long 0x4b8--0x4bb "MDM_HI0_CH14_FLUSH_STATE0_SD1 (at 0x904004b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE0_SD2"
   group.long 0x8b8--0x8bb "MDM_HI0_CH14_FLUSH_STATE0_SD2 (at 0x904008b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE0_SD3"
   group.long 0xcb8--0xcbb "MDM_HI0_CH14_FLUSH_STATE0_SD3 (at 0x90400cb8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE0_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE0_SD0"
   group.long 0xbc--0xbf "MDM_HI0_CH15_FLUSH_STATE0_SD0 (at 0x904000bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE0_SD1"
   group.long 0x4bc--0x4bf "MDM_HI0_CH15_FLUSH_STATE0_SD1 (at 0x904004bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE0_SD2"
   group.long 0x8bc--0x8bf "MDM_HI0_CH15_FLUSH_STATE0_SD2 (at 0x904008bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE0_SD3"
   group.long 0xcbc--0xcbf "MDM_HI0_CH15_FLUSH_STATE0_SD3 (at 0x90400cbc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   FLUSH_TYPE                     = " "0 (FLUSH_SHOULD_DISCARD_ANY_DATA_ALREADY_READ_INTO_DATA_BUFFER),1 (FLUSH_SHOULD_WRITE_ALL_INB_DATA_RECEIVED_OR_REQUESTED_PRIOR_TO_TERMINATING_THE_TOP_LEVEL_COMMAND) "
    textline ""
    hexmask.long.word 0x0 0x15--0x1e 1 "  [30:21]   RESERVED_BITS30_21             = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   CMD_ERR                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   LAST_CPLE_MPU                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   NO_OTB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   NO_INB_INSTR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NO_DATA_XFER                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   DPH_CMD_TYPE                   = " "0 (SINGLE),1 (SCATTER_GATHER),2 (RESERVED_PROGRAMMING),3 (BOX) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PTR_NUM_OVRFLW                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DSCR_INDX_OVRFLW               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   LEN_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MPU_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DPH_BUS_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CPH_BUS_ERROR                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CH_STATE                       = " "0 (IDLE),1 (PROCESS),2 (reserved),3 (FLUSH_WAIT) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   V                              = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE1_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE1_SD0"
   group.long 0xc0--0xc3 "MDM_HI0_CH0_FLUSH_STATE1_SD0 (at 0x904000c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE1_SD1"
   group.long 0x4c0--0x4c3 "MDM_HI0_CH0_FLUSH_STATE1_SD1 (at 0x904004c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE1_SD2"
   group.long 0x8c0--0x8c3 "MDM_HI0_CH0_FLUSH_STATE1_SD2 (at 0x904008c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE1_SD3"
   group.long 0xcc0--0xcc3 "MDM_HI0_CH0_FLUSH_STATE1_SD3 (at 0x90400cc0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE1_SD0"
   group.long 0xc4--0xc7 "MDM_HI0_CH1_FLUSH_STATE1_SD0 (at 0x904000c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE1_SD1"
   group.long 0x4c4--0x4c7 "MDM_HI0_CH1_FLUSH_STATE1_SD1 (at 0x904004c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE1_SD2"
   group.long 0x8c4--0x8c7 "MDM_HI0_CH1_FLUSH_STATE1_SD2 (at 0x904008c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE1_SD3"
   group.long 0xcc4--0xcc7 "MDM_HI0_CH1_FLUSH_STATE1_SD3 (at 0x90400cc4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE1_SD0"
   group.long 0xc8--0xcb "MDM_HI0_CH2_FLUSH_STATE1_SD0 (at 0x904000c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE1_SD1"
   group.long 0x4c8--0x4cb "MDM_HI0_CH2_FLUSH_STATE1_SD1 (at 0x904004c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE1_SD2"
   group.long 0x8c8--0x8cb "MDM_HI0_CH2_FLUSH_STATE1_SD2 (at 0x904008c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE1_SD3"
   group.long 0xcc8--0xccb "MDM_HI0_CH2_FLUSH_STATE1_SD3 (at 0x90400cc8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE1_SD0"
   group.long 0xcc--0xcf "MDM_HI0_CH3_FLUSH_STATE1_SD0 (at 0x904000cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE1_SD1"
   group.long 0x4cc--0x4cf "MDM_HI0_CH3_FLUSH_STATE1_SD1 (at 0x904004cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE1_SD2"
   group.long 0x8cc--0x8cf "MDM_HI0_CH3_FLUSH_STATE1_SD2 (at 0x904008cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE1_SD3"
   group.long 0xccc--0xccf "MDM_HI0_CH3_FLUSH_STATE1_SD3 (at 0x90400ccc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE1_SD0"
   group.long 0xd0--0xd3 "MDM_HI0_CH4_FLUSH_STATE1_SD0 (at 0x904000d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE1_SD1"
   group.long 0x4d0--0x4d3 "MDM_HI0_CH4_FLUSH_STATE1_SD1 (at 0x904004d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE1_SD2"
   group.long 0x8d0--0x8d3 "MDM_HI0_CH4_FLUSH_STATE1_SD2 (at 0x904008d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE1_SD3"
   group.long 0xcd0--0xcd3 "MDM_HI0_CH4_FLUSH_STATE1_SD3 (at 0x90400cd0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE1_SD0"
   group.long 0xd4--0xd7 "MDM_HI0_CH5_FLUSH_STATE1_SD0 (at 0x904000d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE1_SD1"
   group.long 0x4d4--0x4d7 "MDM_HI0_CH5_FLUSH_STATE1_SD1 (at 0x904004d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE1_SD2"
   group.long 0x8d4--0x8d7 "MDM_HI0_CH5_FLUSH_STATE1_SD2 (at 0x904008d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE1_SD3"
   group.long 0xcd4--0xcd7 "MDM_HI0_CH5_FLUSH_STATE1_SD3 (at 0x90400cd4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE1_SD0"
   group.long 0xd8--0xdb "MDM_HI0_CH6_FLUSH_STATE1_SD0 (at 0x904000d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE1_SD1"
   group.long 0x4d8--0x4db "MDM_HI0_CH6_FLUSH_STATE1_SD1 (at 0x904004d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE1_SD2"
   group.long 0x8d8--0x8db "MDM_HI0_CH6_FLUSH_STATE1_SD2 (at 0x904008d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE1_SD3"
   group.long 0xcd8--0xcdb "MDM_HI0_CH6_FLUSH_STATE1_SD3 (at 0x90400cd8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE1_SD0"
   group.long 0xdc--0xdf "MDM_HI0_CH7_FLUSH_STATE1_SD0 (at 0x904000dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE1_SD1"
   group.long 0x4dc--0x4df "MDM_HI0_CH7_FLUSH_STATE1_SD1 (at 0x904004dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE1_SD2"
   group.long 0x8dc--0x8df "MDM_HI0_CH7_FLUSH_STATE1_SD2 (at 0x904008dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE1_SD3"
   group.long 0xcdc--0xcdf "MDM_HI0_CH7_FLUSH_STATE1_SD3 (at 0x90400cdc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE1_SD0"
   group.long 0xe0--0xe3 "MDM_HI0_CH8_FLUSH_STATE1_SD0 (at 0x904000e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE1_SD1"
   group.long 0x4e0--0x4e3 "MDM_HI0_CH8_FLUSH_STATE1_SD1 (at 0x904004e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE1_SD2"
   group.long 0x8e0--0x8e3 "MDM_HI0_CH8_FLUSH_STATE1_SD2 (at 0x904008e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE1_SD3"
   group.long 0xce0--0xce3 "MDM_HI0_CH8_FLUSH_STATE1_SD3 (at 0x90400ce0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE1_SD0"
   group.long 0xe4--0xe7 "MDM_HI0_CH9_FLUSH_STATE1_SD0 (at 0x904000e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE1_SD1"
   group.long 0x4e4--0x4e7 "MDM_HI0_CH9_FLUSH_STATE1_SD1 (at 0x904004e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE1_SD2"
   group.long 0x8e4--0x8e7 "MDM_HI0_CH9_FLUSH_STATE1_SD2 (at 0x904008e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE1_SD3"
   group.long 0xce4--0xce7 "MDM_HI0_CH9_FLUSH_STATE1_SD3 (at 0x90400ce4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE1_SD0"
   group.long 0xe8--0xeb "MDM_HI0_CH10_FLUSH_STATE1_SD0 (at 0x904000e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE1_SD1"
   group.long 0x4e8--0x4eb "MDM_HI0_CH10_FLUSH_STATE1_SD1 (at 0x904004e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE1_SD2"
   group.long 0x8e8--0x8eb "MDM_HI0_CH10_FLUSH_STATE1_SD2 (at 0x904008e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE1_SD3"
   group.long 0xce8--0xceb "MDM_HI0_CH10_FLUSH_STATE1_SD3 (at 0x90400ce8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE1_SD0"
   group.long 0xec--0xef "MDM_HI0_CH11_FLUSH_STATE1_SD0 (at 0x904000ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE1_SD1"
   group.long 0x4ec--0x4ef "MDM_HI0_CH11_FLUSH_STATE1_SD1 (at 0x904004ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE1_SD2"
   group.long 0x8ec--0x8ef "MDM_HI0_CH11_FLUSH_STATE1_SD2 (at 0x904008ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE1_SD3"
   group.long 0xcec--0xcef "MDM_HI0_CH11_FLUSH_STATE1_SD3 (at 0x90400cec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE1_SD0"
   group.long 0xf0--0xf3 "MDM_HI0_CH12_FLUSH_STATE1_SD0 (at 0x904000f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE1_SD1"
   group.long 0x4f0--0x4f3 "MDM_HI0_CH12_FLUSH_STATE1_SD1 (at 0x904004f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE1_SD2"
   group.long 0x8f0--0x8f3 "MDM_HI0_CH12_FLUSH_STATE1_SD2 (at 0x904008f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE1_SD3"
   group.long 0xcf0--0xcf3 "MDM_HI0_CH12_FLUSH_STATE1_SD3 (at 0x90400cf0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE1_SD0"
   group.long 0xf4--0xf7 "MDM_HI0_CH13_FLUSH_STATE1_SD0 (at 0x904000f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE1_SD1"
   group.long 0x4f4--0x4f7 "MDM_HI0_CH13_FLUSH_STATE1_SD1 (at 0x904004f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE1_SD2"
   group.long 0x8f4--0x8f7 "MDM_HI0_CH13_FLUSH_STATE1_SD2 (at 0x904008f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE1_SD3"
   group.long 0xcf4--0xcf7 "MDM_HI0_CH13_FLUSH_STATE1_SD3 (at 0x90400cf4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE1_SD0"
   group.long 0xf8--0xfb "MDM_HI0_CH14_FLUSH_STATE1_SD0 (at 0x904000f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE1_SD1"
   group.long 0x4f8--0x4fb "MDM_HI0_CH14_FLUSH_STATE1_SD1 (at 0x904004f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE1_SD2"
   group.long 0x8f8--0x8fb "MDM_HI0_CH14_FLUSH_STATE1_SD2 (at 0x904008f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE1_SD3"
   group.long 0xcf8--0xcfb "MDM_HI0_CH14_FLUSH_STATE1_SD3 (at 0x90400cf8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE1_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE1_SD0"
   group.long 0xfc--0xff "MDM_HI0_CH15_FLUSH_STATE1_SD0 (at 0x904000fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE1_SD1"
   group.long 0x4fc--0x4ff "MDM_HI0_CH15_FLUSH_STATE1_SD1 (at 0x904004fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE1_SD2"
   group.long 0x8fc--0x8ff "MDM_HI0_CH15_FLUSH_STATE1_SD2 (at 0x904008fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE1_SD3"
   group.long 0xcfc--0xcff "MDM_HI0_CH15_FLUSH_STATE1_SD3 (at 0x90400cfc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ADDR                       = "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE2_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE2_SD0"
   group.long 0x100--0x103 "MDM_HI0_CH0_FLUSH_STATE2_SD0 (at 0x90400100)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE2_SD1"
   group.long 0x500--0x503 "MDM_HI0_CH0_FLUSH_STATE2_SD1 (at 0x90400500)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE2_SD2"
   group.long 0x900--0x903 "MDM_HI0_CH0_FLUSH_STATE2_SD2 (at 0x90400900)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE2_SD3"
   group.long 0xd00--0xd03 "MDM_HI0_CH0_FLUSH_STATE2_SD3 (at 0x90400d00)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE2_SD0"
   group.long 0x104--0x107 "MDM_HI0_CH1_FLUSH_STATE2_SD0 (at 0x90400104)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE2_SD1"
   group.long 0x504--0x507 "MDM_HI0_CH1_FLUSH_STATE2_SD1 (at 0x90400504)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE2_SD2"
   group.long 0x904--0x907 "MDM_HI0_CH1_FLUSH_STATE2_SD2 (at 0x90400904)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE2_SD3"
   group.long 0xd04--0xd07 "MDM_HI0_CH1_FLUSH_STATE2_SD3 (at 0x90400d04)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE2_SD0"
   group.long 0x108--0x10b "MDM_HI0_CH2_FLUSH_STATE2_SD0 (at 0x90400108)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE2_SD1"
   group.long 0x508--0x50b "MDM_HI0_CH2_FLUSH_STATE2_SD1 (at 0x90400508)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE2_SD2"
   group.long 0x908--0x90b "MDM_HI0_CH2_FLUSH_STATE2_SD2 (at 0x90400908)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE2_SD3"
   group.long 0xd08--0xd0b "MDM_HI0_CH2_FLUSH_STATE2_SD3 (at 0x90400d08)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE2_SD0"
   group.long 0x10c--0x10f "MDM_HI0_CH3_FLUSH_STATE2_SD0 (at 0x9040010c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE2_SD1"
   group.long 0x50c--0x50f "MDM_HI0_CH3_FLUSH_STATE2_SD1 (at 0x9040050c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE2_SD2"
   group.long 0x90c--0x90f "MDM_HI0_CH3_FLUSH_STATE2_SD2 (at 0x9040090c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE2_SD3"
   group.long 0xd0c--0xd0f "MDM_HI0_CH3_FLUSH_STATE2_SD3 (at 0x90400d0c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE2_SD0"
   group.long 0x110--0x113 "MDM_HI0_CH4_FLUSH_STATE2_SD0 (at 0x90400110)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE2_SD1"
   group.long 0x510--0x513 "MDM_HI0_CH4_FLUSH_STATE2_SD1 (at 0x90400510)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE2_SD2"
   group.long 0x910--0x913 "MDM_HI0_CH4_FLUSH_STATE2_SD2 (at 0x90400910)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE2_SD3"
   group.long 0xd10--0xd13 "MDM_HI0_CH4_FLUSH_STATE2_SD3 (at 0x90400d10)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE2_SD0"
   group.long 0x114--0x117 "MDM_HI0_CH5_FLUSH_STATE2_SD0 (at 0x90400114)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE2_SD1"
   group.long 0x514--0x517 "MDM_HI0_CH5_FLUSH_STATE2_SD1 (at 0x90400514)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE2_SD2"
   group.long 0x914--0x917 "MDM_HI0_CH5_FLUSH_STATE2_SD2 (at 0x90400914)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE2_SD3"
   group.long 0xd14--0xd17 "MDM_HI0_CH5_FLUSH_STATE2_SD3 (at 0x90400d14)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE2_SD0"
   group.long 0x118--0x11b "MDM_HI0_CH6_FLUSH_STATE2_SD0 (at 0x90400118)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE2_SD1"
   group.long 0x518--0x51b "MDM_HI0_CH6_FLUSH_STATE2_SD1 (at 0x90400518)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE2_SD2"
   group.long 0x918--0x91b "MDM_HI0_CH6_FLUSH_STATE2_SD2 (at 0x90400918)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE2_SD3"
   group.long 0xd18--0xd1b "MDM_HI0_CH6_FLUSH_STATE2_SD3 (at 0x90400d18)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE2_SD0"
   group.long 0x11c--0x11f "MDM_HI0_CH7_FLUSH_STATE2_SD0 (at 0x9040011c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE2_SD1"
   group.long 0x51c--0x51f "MDM_HI0_CH7_FLUSH_STATE2_SD1 (at 0x9040051c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE2_SD2"
   group.long 0x91c--0x91f "MDM_HI0_CH7_FLUSH_STATE2_SD2 (at 0x9040091c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE2_SD3"
   group.long 0xd1c--0xd1f "MDM_HI0_CH7_FLUSH_STATE2_SD3 (at 0x90400d1c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE2_SD0"
   group.long 0x120--0x123 "MDM_HI0_CH8_FLUSH_STATE2_SD0 (at 0x90400120)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE2_SD1"
   group.long 0x520--0x523 "MDM_HI0_CH8_FLUSH_STATE2_SD1 (at 0x90400520)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE2_SD2"
   group.long 0x920--0x923 "MDM_HI0_CH8_FLUSH_STATE2_SD2 (at 0x90400920)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE2_SD3"
   group.long 0xd20--0xd23 "MDM_HI0_CH8_FLUSH_STATE2_SD3 (at 0x90400d20)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE2_SD0"
   group.long 0x124--0x127 "MDM_HI0_CH9_FLUSH_STATE2_SD0 (at 0x90400124)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE2_SD1"
   group.long 0x524--0x527 "MDM_HI0_CH9_FLUSH_STATE2_SD1 (at 0x90400524)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE2_SD2"
   group.long 0x924--0x927 "MDM_HI0_CH9_FLUSH_STATE2_SD2 (at 0x90400924)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE2_SD3"
   group.long 0xd24--0xd27 "MDM_HI0_CH9_FLUSH_STATE2_SD3 (at 0x90400d24)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE2_SD0"
   group.long 0x128--0x12b "MDM_HI0_CH10_FLUSH_STATE2_SD0 (at 0x90400128)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE2_SD1"
   group.long 0x528--0x52b "MDM_HI0_CH10_FLUSH_STATE2_SD1 (at 0x90400528)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE2_SD2"
   group.long 0x928--0x92b "MDM_HI0_CH10_FLUSH_STATE2_SD2 (at 0x90400928)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE2_SD3"
   group.long 0xd28--0xd2b "MDM_HI0_CH10_FLUSH_STATE2_SD3 (at 0x90400d28)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE2_SD0"
   group.long 0x12c--0x12f "MDM_HI0_CH11_FLUSH_STATE2_SD0 (at 0x9040012c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE2_SD1"
   group.long 0x52c--0x52f "MDM_HI0_CH11_FLUSH_STATE2_SD1 (at 0x9040052c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE2_SD2"
   group.long 0x92c--0x92f "MDM_HI0_CH11_FLUSH_STATE2_SD2 (at 0x9040092c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE2_SD3"
   group.long 0xd2c--0xd2f "MDM_HI0_CH11_FLUSH_STATE2_SD3 (at 0x90400d2c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE2_SD0"
   group.long 0x130--0x133 "MDM_HI0_CH12_FLUSH_STATE2_SD0 (at 0x90400130)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE2_SD1"
   group.long 0x530--0x533 "MDM_HI0_CH12_FLUSH_STATE2_SD1 (at 0x90400530)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE2_SD2"
   group.long 0x930--0x933 "MDM_HI0_CH12_FLUSH_STATE2_SD2 (at 0x90400930)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE2_SD3"
   group.long 0xd30--0xd33 "MDM_HI0_CH12_FLUSH_STATE2_SD3 (at 0x90400d30)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE2_SD0"
   group.long 0x134--0x137 "MDM_HI0_CH13_FLUSH_STATE2_SD0 (at 0x90400134)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE2_SD1"
   group.long 0x534--0x537 "MDM_HI0_CH13_FLUSH_STATE2_SD1 (at 0x90400534)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE2_SD2"
   group.long 0x934--0x937 "MDM_HI0_CH13_FLUSH_STATE2_SD2 (at 0x90400934)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE2_SD3"
   group.long 0xd34--0xd37 "MDM_HI0_CH13_FLUSH_STATE2_SD3 (at 0x90400d34)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE2_SD0"
   group.long 0x138--0x13b "MDM_HI0_CH14_FLUSH_STATE2_SD0 (at 0x90400138)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE2_SD1"
   group.long 0x538--0x53b "MDM_HI0_CH14_FLUSH_STATE2_SD1 (at 0x90400538)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE2_SD2"
   group.long 0x938--0x93b "MDM_HI0_CH14_FLUSH_STATE2_SD2 (at 0x90400938)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE2_SD3"
   group.long 0xd38--0xd3b "MDM_HI0_CH14_FLUSH_STATE2_SD3 (at 0x90400d38)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE2_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE2_SD0"
   group.long 0x13c--0x13f "MDM_HI0_CH15_FLUSH_STATE2_SD0 (at 0x9040013c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE2_SD1"
   group.long 0x53c--0x53f "MDM_HI0_CH15_FLUSH_STATE2_SD1 (at 0x9040053c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE2_SD2"
   group.long 0x93c--0x93f "MDM_HI0_CH15_FLUSH_STATE2_SD2 (at 0x9040093c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE2_SD3"
   group.long 0xd3c--0xd3f "MDM_HI0_CH15_FLUSH_STATE2_SD3 (at 0x90400d3c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RESERVED_BITS31_0              = "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE3_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE3_SD0"
   group.long 0x140--0x143 "MDM_HI0_CH0_FLUSH_STATE3_SD0 (at 0x90400140)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE3_SD1"
   group.long 0x540--0x543 "MDM_HI0_CH0_FLUSH_STATE3_SD1 (at 0x90400540)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE3_SD2"
   group.long 0x940--0x943 "MDM_HI0_CH0_FLUSH_STATE3_SD2 (at 0x90400940)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE3_SD3"
   group.long 0xd40--0xd43 "MDM_HI0_CH0_FLUSH_STATE3_SD3 (at 0x90400d40)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE3_SD0"
   group.long 0x144--0x147 "MDM_HI0_CH1_FLUSH_STATE3_SD0 (at 0x90400144)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE3_SD1"
   group.long 0x544--0x547 "MDM_HI0_CH1_FLUSH_STATE3_SD1 (at 0x90400544)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE3_SD2"
   group.long 0x944--0x947 "MDM_HI0_CH1_FLUSH_STATE3_SD2 (at 0x90400944)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE3_SD3"
   group.long 0xd44--0xd47 "MDM_HI0_CH1_FLUSH_STATE3_SD3 (at 0x90400d44)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE3_SD0"
   group.long 0x148--0x14b "MDM_HI0_CH2_FLUSH_STATE3_SD0 (at 0x90400148)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE3_SD1"
   group.long 0x548--0x54b "MDM_HI0_CH2_FLUSH_STATE3_SD1 (at 0x90400548)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE3_SD2"
   group.long 0x948--0x94b "MDM_HI0_CH2_FLUSH_STATE3_SD2 (at 0x90400948)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE3_SD3"
   group.long 0xd48--0xd4b "MDM_HI0_CH2_FLUSH_STATE3_SD3 (at 0x90400d48)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE3_SD0"
   group.long 0x14c--0x14f "MDM_HI0_CH3_FLUSH_STATE3_SD0 (at 0x9040014c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE3_SD1"
   group.long 0x54c--0x54f "MDM_HI0_CH3_FLUSH_STATE3_SD1 (at 0x9040054c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE3_SD2"
   group.long 0x94c--0x94f "MDM_HI0_CH3_FLUSH_STATE3_SD2 (at 0x9040094c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE3_SD3"
   group.long 0xd4c--0xd4f "MDM_HI0_CH3_FLUSH_STATE3_SD3 (at 0x90400d4c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE3_SD0"
   group.long 0x150--0x153 "MDM_HI0_CH4_FLUSH_STATE3_SD0 (at 0x90400150)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE3_SD1"
   group.long 0x550--0x553 "MDM_HI0_CH4_FLUSH_STATE3_SD1 (at 0x90400550)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE3_SD2"
   group.long 0x950--0x953 "MDM_HI0_CH4_FLUSH_STATE3_SD2 (at 0x90400950)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE3_SD3"
   group.long 0xd50--0xd53 "MDM_HI0_CH4_FLUSH_STATE3_SD3 (at 0x90400d50)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE3_SD0"
   group.long 0x154--0x157 "MDM_HI0_CH5_FLUSH_STATE3_SD0 (at 0x90400154)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE3_SD1"
   group.long 0x554--0x557 "MDM_HI0_CH5_FLUSH_STATE3_SD1 (at 0x90400554)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE3_SD2"
   group.long 0x954--0x957 "MDM_HI0_CH5_FLUSH_STATE3_SD2 (at 0x90400954)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE3_SD3"
   group.long 0xd54--0xd57 "MDM_HI0_CH5_FLUSH_STATE3_SD3 (at 0x90400d54)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE3_SD0"
   group.long 0x158--0x15b "MDM_HI0_CH6_FLUSH_STATE3_SD0 (at 0x90400158)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE3_SD1"
   group.long 0x558--0x55b "MDM_HI0_CH6_FLUSH_STATE3_SD1 (at 0x90400558)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE3_SD2"
   group.long 0x958--0x95b "MDM_HI0_CH6_FLUSH_STATE3_SD2 (at 0x90400958)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE3_SD3"
   group.long 0xd58--0xd5b "MDM_HI0_CH6_FLUSH_STATE3_SD3 (at 0x90400d58)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE3_SD0"
   group.long 0x15c--0x15f "MDM_HI0_CH7_FLUSH_STATE3_SD0 (at 0x9040015c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE3_SD1"
   group.long 0x55c--0x55f "MDM_HI0_CH7_FLUSH_STATE3_SD1 (at 0x9040055c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE3_SD2"
   group.long 0x95c--0x95f "MDM_HI0_CH7_FLUSH_STATE3_SD2 (at 0x9040095c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE3_SD3"
   group.long 0xd5c--0xd5f "MDM_HI0_CH7_FLUSH_STATE3_SD3 (at 0x90400d5c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE3_SD0"
   group.long 0x160--0x163 "MDM_HI0_CH8_FLUSH_STATE3_SD0 (at 0x90400160)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE3_SD1"
   group.long 0x560--0x563 "MDM_HI0_CH8_FLUSH_STATE3_SD1 (at 0x90400560)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE3_SD2"
   group.long 0x960--0x963 "MDM_HI0_CH8_FLUSH_STATE3_SD2 (at 0x90400960)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE3_SD3"
   group.long 0xd60--0xd63 "MDM_HI0_CH8_FLUSH_STATE3_SD3 (at 0x90400d60)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE3_SD0"
   group.long 0x164--0x167 "MDM_HI0_CH9_FLUSH_STATE3_SD0 (at 0x90400164)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE3_SD1"
   group.long 0x564--0x567 "MDM_HI0_CH9_FLUSH_STATE3_SD1 (at 0x90400564)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE3_SD2"
   group.long 0x964--0x967 "MDM_HI0_CH9_FLUSH_STATE3_SD2 (at 0x90400964)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE3_SD3"
   group.long 0xd64--0xd67 "MDM_HI0_CH9_FLUSH_STATE3_SD3 (at 0x90400d64)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE3_SD0"
   group.long 0x168--0x16b "MDM_HI0_CH10_FLUSH_STATE3_SD0 (at 0x90400168)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE3_SD1"
   group.long 0x568--0x56b "MDM_HI0_CH10_FLUSH_STATE3_SD1 (at 0x90400568)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE3_SD2"
   group.long 0x968--0x96b "MDM_HI0_CH10_FLUSH_STATE3_SD2 (at 0x90400968)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE3_SD3"
   group.long 0xd68--0xd6b "MDM_HI0_CH10_FLUSH_STATE3_SD3 (at 0x90400d68)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE3_SD0"
   group.long 0x16c--0x16f "MDM_HI0_CH11_FLUSH_STATE3_SD0 (at 0x9040016c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE3_SD1"
   group.long 0x56c--0x56f "MDM_HI0_CH11_FLUSH_STATE3_SD1 (at 0x9040056c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE3_SD2"
   group.long 0x96c--0x96f "MDM_HI0_CH11_FLUSH_STATE3_SD2 (at 0x9040096c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE3_SD3"
   group.long 0xd6c--0xd6f "MDM_HI0_CH11_FLUSH_STATE3_SD3 (at 0x90400d6c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE3_SD0"
   group.long 0x170--0x173 "MDM_HI0_CH12_FLUSH_STATE3_SD0 (at 0x90400170)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE3_SD1"
   group.long 0x570--0x573 "MDM_HI0_CH12_FLUSH_STATE3_SD1 (at 0x90400570)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE3_SD2"
   group.long 0x970--0x973 "MDM_HI0_CH12_FLUSH_STATE3_SD2 (at 0x90400970)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE3_SD3"
   group.long 0xd70--0xd73 "MDM_HI0_CH12_FLUSH_STATE3_SD3 (at 0x90400d70)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE3_SD0"
   group.long 0x174--0x177 "MDM_HI0_CH13_FLUSH_STATE3_SD0 (at 0x90400174)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE3_SD1"
   group.long 0x574--0x577 "MDM_HI0_CH13_FLUSH_STATE3_SD1 (at 0x90400574)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE3_SD2"
   group.long 0x974--0x977 "MDM_HI0_CH13_FLUSH_STATE3_SD2 (at 0x90400974)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE3_SD3"
   group.long 0xd74--0xd77 "MDM_HI0_CH13_FLUSH_STATE3_SD3 (at 0x90400d74)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE3_SD0"
   group.long 0x178--0x17b "MDM_HI0_CH14_FLUSH_STATE3_SD0 (at 0x90400178)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE3_SD1"
   group.long 0x578--0x57b "MDM_HI0_CH14_FLUSH_STATE3_SD1 (at 0x90400578)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE3_SD2"
   group.long 0x978--0x97b "MDM_HI0_CH14_FLUSH_STATE3_SD2 (at 0x90400978)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE3_SD3"
   group.long 0xd78--0xd7b "MDM_HI0_CH14_FLUSH_STATE3_SD3 (at 0x90400d78)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE3_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE3_SD0"
   group.long 0x17c--0x17f "MDM_HI0_CH15_FLUSH_STATE3_SD0 (at 0x9040017c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE3_SD1"
   group.long 0x57c--0x57f "MDM_HI0_CH15_FLUSH_STATE3_SD1 (at 0x9040057c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE3_SD2"
   group.long 0x97c--0x97f "MDM_HI0_CH15_FLUSH_STATE3_SD2 (at 0x9040097c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE3_SD3"
   group.long 0xd7c--0xd7f "MDM_HI0_CH15_FLUSH_STATE3_SD3 (at 0x90400d7c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_REM_LEN                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_REM_LEN                    = "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE4_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE4_SD0"
   group.long 0x180--0x183 "MDM_HI0_CH0_FLUSH_STATE4_SD0 (at 0x90400180)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE4_SD1"
   group.long 0x580--0x583 "MDM_HI0_CH0_FLUSH_STATE4_SD1 (at 0x90400580)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE4_SD2"
   group.long 0x980--0x983 "MDM_HI0_CH0_FLUSH_STATE4_SD2 (at 0x90400980)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE4_SD3"
   group.long 0xd80--0xd83 "MDM_HI0_CH0_FLUSH_STATE4_SD3 (at 0x90400d80)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE4_SD0"
   group.long 0x184--0x187 "MDM_HI0_CH1_FLUSH_STATE4_SD0 (at 0x90400184)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE4_SD1"
   group.long 0x584--0x587 "MDM_HI0_CH1_FLUSH_STATE4_SD1 (at 0x90400584)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE4_SD2"
   group.long 0x984--0x987 "MDM_HI0_CH1_FLUSH_STATE4_SD2 (at 0x90400984)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE4_SD3"
   group.long 0xd84--0xd87 "MDM_HI0_CH1_FLUSH_STATE4_SD3 (at 0x90400d84)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE4_SD0"
   group.long 0x188--0x18b "MDM_HI0_CH2_FLUSH_STATE4_SD0 (at 0x90400188)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE4_SD1"
   group.long 0x588--0x58b "MDM_HI0_CH2_FLUSH_STATE4_SD1 (at 0x90400588)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE4_SD2"
   group.long 0x988--0x98b "MDM_HI0_CH2_FLUSH_STATE4_SD2 (at 0x90400988)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE4_SD3"
   group.long 0xd88--0xd8b "MDM_HI0_CH2_FLUSH_STATE4_SD3 (at 0x90400d88)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE4_SD0"
   group.long 0x18c--0x18f "MDM_HI0_CH3_FLUSH_STATE4_SD0 (at 0x9040018c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE4_SD1"
   group.long 0x58c--0x58f "MDM_HI0_CH3_FLUSH_STATE4_SD1 (at 0x9040058c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE4_SD2"
   group.long 0x98c--0x98f "MDM_HI0_CH3_FLUSH_STATE4_SD2 (at 0x9040098c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE4_SD3"
   group.long 0xd8c--0xd8f "MDM_HI0_CH3_FLUSH_STATE4_SD3 (at 0x90400d8c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE4_SD0"
   group.long 0x190--0x193 "MDM_HI0_CH4_FLUSH_STATE4_SD0 (at 0x90400190)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE4_SD1"
   group.long 0x590--0x593 "MDM_HI0_CH4_FLUSH_STATE4_SD1 (at 0x90400590)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE4_SD2"
   group.long 0x990--0x993 "MDM_HI0_CH4_FLUSH_STATE4_SD2 (at 0x90400990)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE4_SD3"
   group.long 0xd90--0xd93 "MDM_HI0_CH4_FLUSH_STATE4_SD3 (at 0x90400d90)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE4_SD0"
   group.long 0x194--0x197 "MDM_HI0_CH5_FLUSH_STATE4_SD0 (at 0x90400194)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE4_SD1"
   group.long 0x594--0x597 "MDM_HI0_CH5_FLUSH_STATE4_SD1 (at 0x90400594)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE4_SD2"
   group.long 0x994--0x997 "MDM_HI0_CH5_FLUSH_STATE4_SD2 (at 0x90400994)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE4_SD3"
   group.long 0xd94--0xd97 "MDM_HI0_CH5_FLUSH_STATE4_SD3 (at 0x90400d94)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE4_SD0"
   group.long 0x198--0x19b "MDM_HI0_CH6_FLUSH_STATE4_SD0 (at 0x90400198)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE4_SD1"
   group.long 0x598--0x59b "MDM_HI0_CH6_FLUSH_STATE4_SD1 (at 0x90400598)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE4_SD2"
   group.long 0x998--0x99b "MDM_HI0_CH6_FLUSH_STATE4_SD2 (at 0x90400998)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE4_SD3"
   group.long 0xd98--0xd9b "MDM_HI0_CH6_FLUSH_STATE4_SD3 (at 0x90400d98)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE4_SD0"
   group.long 0x19c--0x19f "MDM_HI0_CH7_FLUSH_STATE4_SD0 (at 0x9040019c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE4_SD1"
   group.long 0x59c--0x59f "MDM_HI0_CH7_FLUSH_STATE4_SD1 (at 0x9040059c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE4_SD2"
   group.long 0x99c--0x99f "MDM_HI0_CH7_FLUSH_STATE4_SD2 (at 0x9040099c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE4_SD3"
   group.long 0xd9c--0xd9f "MDM_HI0_CH7_FLUSH_STATE4_SD3 (at 0x90400d9c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE4_SD0"
   group.long 0x1a0--0x1a3 "MDM_HI0_CH8_FLUSH_STATE4_SD0 (at 0x904001a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE4_SD1"
   group.long 0x5a0--0x5a3 "MDM_HI0_CH8_FLUSH_STATE4_SD1 (at 0x904005a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE4_SD2"
   group.long 0x9a0--0x9a3 "MDM_HI0_CH8_FLUSH_STATE4_SD2 (at 0x904009a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE4_SD3"
   group.long 0xda0--0xda3 "MDM_HI0_CH8_FLUSH_STATE4_SD3 (at 0x90400da0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE4_SD0"
   group.long 0x1a4--0x1a7 "MDM_HI0_CH9_FLUSH_STATE4_SD0 (at 0x904001a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE4_SD1"
   group.long 0x5a4--0x5a7 "MDM_HI0_CH9_FLUSH_STATE4_SD1 (at 0x904005a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE4_SD2"
   group.long 0x9a4--0x9a7 "MDM_HI0_CH9_FLUSH_STATE4_SD2 (at 0x904009a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE4_SD3"
   group.long 0xda4--0xda7 "MDM_HI0_CH9_FLUSH_STATE4_SD3 (at 0x90400da4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE4_SD0"
   group.long 0x1a8--0x1ab "MDM_HI0_CH10_FLUSH_STATE4_SD0 (at 0x904001a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE4_SD1"
   group.long 0x5a8--0x5ab "MDM_HI0_CH10_FLUSH_STATE4_SD1 (at 0x904005a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE4_SD2"
   group.long 0x9a8--0x9ab "MDM_HI0_CH10_FLUSH_STATE4_SD2 (at 0x904009a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE4_SD3"
   group.long 0xda8--0xdab "MDM_HI0_CH10_FLUSH_STATE4_SD3 (at 0x90400da8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE4_SD0"
   group.long 0x1ac--0x1af "MDM_HI0_CH11_FLUSH_STATE4_SD0 (at 0x904001ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE4_SD1"
   group.long 0x5ac--0x5af "MDM_HI0_CH11_FLUSH_STATE4_SD1 (at 0x904005ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE4_SD2"
   group.long 0x9ac--0x9af "MDM_HI0_CH11_FLUSH_STATE4_SD2 (at 0x904009ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE4_SD3"
   group.long 0xdac--0xdaf "MDM_HI0_CH11_FLUSH_STATE4_SD3 (at 0x90400dac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE4_SD0"
   group.long 0x1b0--0x1b3 "MDM_HI0_CH12_FLUSH_STATE4_SD0 (at 0x904001b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE4_SD1"
   group.long 0x5b0--0x5b3 "MDM_HI0_CH12_FLUSH_STATE4_SD1 (at 0x904005b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE4_SD2"
   group.long 0x9b0--0x9b3 "MDM_HI0_CH12_FLUSH_STATE4_SD2 (at 0x904009b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE4_SD3"
   group.long 0xdb0--0xdb3 "MDM_HI0_CH12_FLUSH_STATE4_SD3 (at 0x90400db0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE4_SD0"
   group.long 0x1b4--0x1b7 "MDM_HI0_CH13_FLUSH_STATE4_SD0 (at 0x904001b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE4_SD1"
   group.long 0x5b4--0x5b7 "MDM_HI0_CH13_FLUSH_STATE4_SD1 (at 0x904005b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE4_SD2"
   group.long 0x9b4--0x9b7 "MDM_HI0_CH13_FLUSH_STATE4_SD2 (at 0x904009b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE4_SD3"
   group.long 0xdb4--0xdb7 "MDM_HI0_CH13_FLUSH_STATE4_SD3 (at 0x90400db4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE4_SD0"
   group.long 0x1b8--0x1bb "MDM_HI0_CH14_FLUSH_STATE4_SD0 (at 0x904001b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE4_SD1"
   group.long 0x5b8--0x5bb "MDM_HI0_CH14_FLUSH_STATE4_SD1 (at 0x904005b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE4_SD2"
   group.long 0x9b8--0x9bb "MDM_HI0_CH14_FLUSH_STATE4_SD2 (at 0x904009b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE4_SD3"
   group.long 0xdb8--0xdbb "MDM_HI0_CH14_FLUSH_STATE4_SD3 (at 0x90400db8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE4_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE4_SD0"
   group.long 0x1bc--0x1bf "MDM_HI0_CH15_FLUSH_STATE4_SD0 (at 0x904001bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE4_SD1"
   group.long 0x5bc--0x5bf "MDM_HI0_CH15_FLUSH_STATE4_SD1 (at 0x904005bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE4_SD2"
   group.long 0x9bc--0x9bf "MDM_HI0_CH15_FLUSH_STATE4_SD2 (at 0x904009bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE4_SD3"
   group.long 0xdbc--0xdbf "MDM_HI0_CH15_FLUSH_STATE4_SD3 (at 0x90400dbc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DST_DSCR_NUM                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SRC_DSCR_NUM                   = "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_FLUSH_STATE5_SDs"
 tree "MDM_HI0_CH0_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH0_FLUSH_STATE5_SD0"
   group.long 0x1c0--0x1c3 "MDM_HI0_CH0_FLUSH_STATE5_SD0 (at 0x904001c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE5_SD1"
   group.long 0x5c0--0x5c3 "MDM_HI0_CH0_FLUSH_STATE5_SD1 (at 0x904005c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE5_SD2"
   group.long 0x9c0--0x9c3 "MDM_HI0_CH0_FLUSH_STATE5_SD2 (at 0x904009c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH0_FLUSH_STATE5_SD3"
   group.long 0xdc0--0xdc3 "MDM_HI0_CH0_FLUSH_STATE5_SD3 (at 0x90400dc0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH1_FLUSH_STATE5_SD0"
   group.long 0x1c4--0x1c7 "MDM_HI0_CH1_FLUSH_STATE5_SD0 (at 0x904001c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE5_SD1"
   group.long 0x5c4--0x5c7 "MDM_HI0_CH1_FLUSH_STATE5_SD1 (at 0x904005c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE5_SD2"
   group.long 0x9c4--0x9c7 "MDM_HI0_CH1_FLUSH_STATE5_SD2 (at 0x904009c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH1_FLUSH_STATE5_SD3"
   group.long 0xdc4--0xdc7 "MDM_HI0_CH1_FLUSH_STATE5_SD3 (at 0x90400dc4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH2_FLUSH_STATE5_SD0"
   group.long 0x1c8--0x1cb "MDM_HI0_CH2_FLUSH_STATE5_SD0 (at 0x904001c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE5_SD1"
   group.long 0x5c8--0x5cb "MDM_HI0_CH2_FLUSH_STATE5_SD1 (at 0x904005c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE5_SD2"
   group.long 0x9c8--0x9cb "MDM_HI0_CH2_FLUSH_STATE5_SD2 (at 0x904009c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH2_FLUSH_STATE5_SD3"
   group.long 0xdc8--0xdcb "MDM_HI0_CH2_FLUSH_STATE5_SD3 (at 0x90400dc8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH3_FLUSH_STATE5_SD0"
   group.long 0x1cc--0x1cf "MDM_HI0_CH3_FLUSH_STATE5_SD0 (at 0x904001cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE5_SD1"
   group.long 0x5cc--0x5cf "MDM_HI0_CH3_FLUSH_STATE5_SD1 (at 0x904005cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE5_SD2"
   group.long 0x9cc--0x9cf "MDM_HI0_CH3_FLUSH_STATE5_SD2 (at 0x904009cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH3_FLUSH_STATE5_SD3"
   group.long 0xdcc--0xdcf "MDM_HI0_CH3_FLUSH_STATE5_SD3 (at 0x90400dcc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH4_FLUSH_STATE5_SD0"
   group.long 0x1d0--0x1d3 "MDM_HI0_CH4_FLUSH_STATE5_SD0 (at 0x904001d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE5_SD1"
   group.long 0x5d0--0x5d3 "MDM_HI0_CH4_FLUSH_STATE5_SD1 (at 0x904005d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE5_SD2"
   group.long 0x9d0--0x9d3 "MDM_HI0_CH4_FLUSH_STATE5_SD2 (at 0x904009d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH4_FLUSH_STATE5_SD3"
   group.long 0xdd0--0xdd3 "MDM_HI0_CH4_FLUSH_STATE5_SD3 (at 0x90400dd0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH5_FLUSH_STATE5_SD0"
   group.long 0x1d4--0x1d7 "MDM_HI0_CH5_FLUSH_STATE5_SD0 (at 0x904001d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE5_SD1"
   group.long 0x5d4--0x5d7 "MDM_HI0_CH5_FLUSH_STATE5_SD1 (at 0x904005d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE5_SD2"
   group.long 0x9d4--0x9d7 "MDM_HI0_CH5_FLUSH_STATE5_SD2 (at 0x904009d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH5_FLUSH_STATE5_SD3"
   group.long 0xdd4--0xdd7 "MDM_HI0_CH5_FLUSH_STATE5_SD3 (at 0x90400dd4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH6_FLUSH_STATE5_SD0"
   group.long 0x1d8--0x1db "MDM_HI0_CH6_FLUSH_STATE5_SD0 (at 0x904001d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE5_SD1"
   group.long 0x5d8--0x5db "MDM_HI0_CH6_FLUSH_STATE5_SD1 (at 0x904005d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE5_SD2"
   group.long 0x9d8--0x9db "MDM_HI0_CH6_FLUSH_STATE5_SD2 (at 0x904009d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH6_FLUSH_STATE5_SD3"
   group.long 0xdd8--0xddb "MDM_HI0_CH6_FLUSH_STATE5_SD3 (at 0x90400dd8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH7_FLUSH_STATE5_SD0"
   group.long 0x1dc--0x1df "MDM_HI0_CH7_FLUSH_STATE5_SD0 (at 0x904001dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE5_SD1"
   group.long 0x5dc--0x5df "MDM_HI0_CH7_FLUSH_STATE5_SD1 (at 0x904005dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE5_SD2"
   group.long 0x9dc--0x9df "MDM_HI0_CH7_FLUSH_STATE5_SD2 (at 0x904009dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH7_FLUSH_STATE5_SD3"
   group.long 0xddc--0xddf "MDM_HI0_CH7_FLUSH_STATE5_SD3 (at 0x90400ddc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH8_FLUSH_STATE5_SD0"
   group.long 0x1e0--0x1e3 "MDM_HI0_CH8_FLUSH_STATE5_SD0 (at 0x904001e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE5_SD1"
   group.long 0x5e0--0x5e3 "MDM_HI0_CH8_FLUSH_STATE5_SD1 (at 0x904005e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE5_SD2"
   group.long 0x9e0--0x9e3 "MDM_HI0_CH8_FLUSH_STATE5_SD2 (at 0x904009e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH8_FLUSH_STATE5_SD3"
   group.long 0xde0--0xde3 "MDM_HI0_CH8_FLUSH_STATE5_SD3 (at 0x90400de0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH9_FLUSH_STATE5_SD0"
   group.long 0x1e4--0x1e7 "MDM_HI0_CH9_FLUSH_STATE5_SD0 (at 0x904001e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE5_SD1"
   group.long 0x5e4--0x5e7 "MDM_HI0_CH9_FLUSH_STATE5_SD1 (at 0x904005e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE5_SD2"
   group.long 0x9e4--0x9e7 "MDM_HI0_CH9_FLUSH_STATE5_SD2 (at 0x904009e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH9_FLUSH_STATE5_SD3"
   group.long 0xde4--0xde7 "MDM_HI0_CH9_FLUSH_STATE5_SD3 (at 0x90400de4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH10_FLUSH_STATE5_SD0"
   group.long 0x1e8--0x1eb "MDM_HI0_CH10_FLUSH_STATE5_SD0 (at 0x904001e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE5_SD1"
   group.long 0x5e8--0x5eb "MDM_HI0_CH10_FLUSH_STATE5_SD1 (at 0x904005e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE5_SD2"
   group.long 0x9e8--0x9eb "MDM_HI0_CH10_FLUSH_STATE5_SD2 (at 0x904009e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH10_FLUSH_STATE5_SD3"
   group.long 0xde8--0xdeb "MDM_HI0_CH10_FLUSH_STATE5_SD3 (at 0x90400de8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH11_FLUSH_STATE5_SD0"
   group.long 0x1ec--0x1ef "MDM_HI0_CH11_FLUSH_STATE5_SD0 (at 0x904001ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE5_SD1"
   group.long 0x5ec--0x5ef "MDM_HI0_CH11_FLUSH_STATE5_SD1 (at 0x904005ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE5_SD2"
   group.long 0x9ec--0x9ef "MDM_HI0_CH11_FLUSH_STATE5_SD2 (at 0x904009ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH11_FLUSH_STATE5_SD3"
   group.long 0xdec--0xdef "MDM_HI0_CH11_FLUSH_STATE5_SD3 (at 0x90400dec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH12_FLUSH_STATE5_SD0"
   group.long 0x1f0--0x1f3 "MDM_HI0_CH12_FLUSH_STATE5_SD0 (at 0x904001f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE5_SD1"
   group.long 0x5f0--0x5f3 "MDM_HI0_CH12_FLUSH_STATE5_SD1 (at 0x904005f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE5_SD2"
   group.long 0x9f0--0x9f3 "MDM_HI0_CH12_FLUSH_STATE5_SD2 (at 0x904009f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH12_FLUSH_STATE5_SD3"
   group.long 0xdf0--0xdf3 "MDM_HI0_CH12_FLUSH_STATE5_SD3 (at 0x90400df0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH13_FLUSH_STATE5_SD0"
   group.long 0x1f4--0x1f7 "MDM_HI0_CH13_FLUSH_STATE5_SD0 (at 0x904001f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE5_SD1"
   group.long 0x5f4--0x5f7 "MDM_HI0_CH13_FLUSH_STATE5_SD1 (at 0x904005f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE5_SD2"
   group.long 0x9f4--0x9f7 "MDM_HI0_CH13_FLUSH_STATE5_SD2 (at 0x904009f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH13_FLUSH_STATE5_SD3"
   group.long 0xdf4--0xdf7 "MDM_HI0_CH13_FLUSH_STATE5_SD3 (at 0x90400df4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH14_FLUSH_STATE5_SD0"
   group.long 0x1f8--0x1fb "MDM_HI0_CH14_FLUSH_STATE5_SD0 (at 0x904001f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE5_SD1"
   group.long 0x5f8--0x5fb "MDM_HI0_CH14_FLUSH_STATE5_SD1 (at 0x904005f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE5_SD2"
   group.long 0x9f8--0x9fb "MDM_HI0_CH14_FLUSH_STATE5_SD2 (at 0x904009f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH14_FLUSH_STATE5_SD3"
   group.long 0xdf8--0xdfb "MDM_HI0_CH14_FLUSH_STATE5_SD3 (at 0x90400df8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_FLUSH_STATE5_SDs"
  tree "MDM_HI0_CH15_FLUSH_STATE5_SD0"
   group.long 0x1fc--0x1ff "MDM_HI0_CH15_FLUSH_STATE5_SD0 (at 0x904001fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE5_SD1"
   group.long 0x5fc--0x5ff "MDM_HI0_CH15_FLUSH_STATE5_SD1 (at 0x904005fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE5_SD2"
   group.long 0x9fc--0x9ff "MDM_HI0_CH15_FLUSH_STATE5_SD2 (at 0x904009fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDM_HI0_CH15_FLUSH_STATE5_SD3"
   group.long 0xdfc--0xdff "MDM_HI0_CH15_FLUSH_STATE5_SD3 (at 0x90400dfc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   PTR_NUM                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   DSCR_INDX_NUM                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BUFFERED_LEN                   = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RESERVED_BITS2_0               = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SDs"
  tree "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD0"
   group.long 0x380--0x383 "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD0 (at 0x90400380)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CH_15_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CH_14_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CH_13_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   CH_12_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CH_11_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CH_10_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CH_9_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CH_8_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CH_7_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CH_6_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CH_5_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CH_4_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CH_3_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH_2_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CH_1_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH_0_IRQ                       = " "0,1 "
  tree.end
  tree "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD1"
   group.long 0x13a4--0x13a7 "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD1 (at 0x904013a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CH_15_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CH_14_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CH_13_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   CH_12_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CH_11_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CH_10_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CH_9_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CH_8_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CH_7_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CH_6_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CH_5_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CH_4_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CH_3_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH_2_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CH_1_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH_0_IRQ                       = " "0,1 "
  tree.end
  tree "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD2"
   group.long 0x23c8--0x23cb "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD2 (at 0x904023c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CH_15_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CH_14_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CH_13_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   CH_12_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CH_11_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CH_10_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CH_9_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CH_8_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CH_7_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CH_6_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CH_5_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CH_4_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CH_3_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH_2_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CH_1_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH_0_IRQ                       = " "0,1 "
  tree.end
  tree "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD3"
   group.long 0x33ec--0x33ef "MDM_HI0_SEC_DOMAIN_IRQ_STATUS_SD3 (at 0x904033ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CH_15_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CH_14_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CH_13_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   CH_12_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CH_11_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CH_10_IRQ                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CH_9_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CH_8_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CH_7_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CH_6_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CH_5_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   CH_4_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CH_3_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CH_2_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CH_1_IRQ                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CH_0_IRQ                       = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CHn_RSLT_CONF_SDs"
 tree "MDM_HI0_CH0_RSLT_CONF_SDs"
  tree "MDM_HI0_CH0_RSLT_CONF_SD0"
   group.long 0x300--0x303 "MDM_HI0_CH0_RSLT_CONF_SD0 (at 0x90400300) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_CONF_SD1"
   group.long 0x700--0x703 "MDM_HI0_CH0_RSLT_CONF_SD1 (at 0x90400700)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_CONF_SD2"
   group.long 0xb00--0xb03 "MDM_HI0_CH0_RSLT_CONF_SD2 (at 0x90400b00)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_RSLT_CONF_SD3"
   group.long 0xf00--0xf03 "MDM_HI0_CH0_RSLT_CONF_SD3 (at 0x90400f00)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_RSLT_CONF_SDs"
  tree "MDM_HI0_CH1_RSLT_CONF_SD0"
   group.long 0x304--0x307 "MDM_HI0_CH1_RSLT_CONF_SD0 (at 0x90400304)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_CONF_SD1"
   group.long 0x704--0x707 "MDM_HI0_CH1_RSLT_CONF_SD1 (at 0x90400704)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_CONF_SD2"
   group.long 0xb04--0xb07 "MDM_HI0_CH1_RSLT_CONF_SD2 (at 0x90400b04)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_RSLT_CONF_SD3"
   group.long 0xf04--0xf07 "MDM_HI0_CH1_RSLT_CONF_SD3 (at 0x90400f04)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_RSLT_CONF_SDs"
  tree "MDM_HI0_CH2_RSLT_CONF_SD0"
   group.long 0x308--0x30b "MDM_HI0_CH2_RSLT_CONF_SD0 (at 0x90400308)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_CONF_SD1"
   group.long 0x708--0x70b "MDM_HI0_CH2_RSLT_CONF_SD1 (at 0x90400708)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_CONF_SD2"
   group.long 0xb08--0xb0b "MDM_HI0_CH2_RSLT_CONF_SD2 (at 0x90400b08)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_RSLT_CONF_SD3"
   group.long 0xf08--0xf0b "MDM_HI0_CH2_RSLT_CONF_SD3 (at 0x90400f08)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_RSLT_CONF_SDs"
  tree "MDM_HI0_CH3_RSLT_CONF_SD0"
   group.long 0x30c--0x30f "MDM_HI0_CH3_RSLT_CONF_SD0 (at 0x9040030c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_CONF_SD1"
   group.long 0x70c--0x70f "MDM_HI0_CH3_RSLT_CONF_SD1 (at 0x9040070c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_CONF_SD2"
   group.long 0xb0c--0xb0f "MDM_HI0_CH3_RSLT_CONF_SD2 (at 0x90400b0c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_RSLT_CONF_SD3"
   group.long 0xf0c--0xf0f "MDM_HI0_CH3_RSLT_CONF_SD3 (at 0x90400f0c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_RSLT_CONF_SDs"
  tree "MDM_HI0_CH4_RSLT_CONF_SD0"
   group.long 0x310--0x313 "MDM_HI0_CH4_RSLT_CONF_SD0 (at 0x90400310)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_CONF_SD1"
   group.long 0x710--0x713 "MDM_HI0_CH4_RSLT_CONF_SD1 (at 0x90400710)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_CONF_SD2"
   group.long 0xb10--0xb13 "MDM_HI0_CH4_RSLT_CONF_SD2 (at 0x90400b10)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_RSLT_CONF_SD3"
   group.long 0xf10--0xf13 "MDM_HI0_CH4_RSLT_CONF_SD3 (at 0x90400f10)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_RSLT_CONF_SDs"
  tree "MDM_HI0_CH5_RSLT_CONF_SD0"
   group.long 0x314--0x317 "MDM_HI0_CH5_RSLT_CONF_SD0 (at 0x90400314)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_CONF_SD1"
   group.long 0x714--0x717 "MDM_HI0_CH5_RSLT_CONF_SD1 (at 0x90400714)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_CONF_SD2"
   group.long 0xb14--0xb17 "MDM_HI0_CH5_RSLT_CONF_SD2 (at 0x90400b14)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_RSLT_CONF_SD3"
   group.long 0xf14--0xf17 "MDM_HI0_CH5_RSLT_CONF_SD3 (at 0x90400f14)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_RSLT_CONF_SDs"
  tree "MDM_HI0_CH6_RSLT_CONF_SD0"
   group.long 0x318--0x31b "MDM_HI0_CH6_RSLT_CONF_SD0 (at 0x90400318)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_CONF_SD1"
   group.long 0x718--0x71b "MDM_HI0_CH6_RSLT_CONF_SD1 (at 0x90400718)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_CONF_SD2"
   group.long 0xb18--0xb1b "MDM_HI0_CH6_RSLT_CONF_SD2 (at 0x90400b18)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_RSLT_CONF_SD3"
   group.long 0xf18--0xf1b "MDM_HI0_CH6_RSLT_CONF_SD3 (at 0x90400f18)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_RSLT_CONF_SDs"
  tree "MDM_HI0_CH7_RSLT_CONF_SD0"
   group.long 0x31c--0x31f "MDM_HI0_CH7_RSLT_CONF_SD0 (at 0x9040031c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_CONF_SD1"
   group.long 0x71c--0x71f "MDM_HI0_CH7_RSLT_CONF_SD1 (at 0x9040071c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_CONF_SD2"
   group.long 0xb1c--0xb1f "MDM_HI0_CH7_RSLT_CONF_SD2 (at 0x90400b1c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_RSLT_CONF_SD3"
   group.long 0xf1c--0xf1f "MDM_HI0_CH7_RSLT_CONF_SD3 (at 0x90400f1c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_RSLT_CONF_SDs"
  tree "MDM_HI0_CH8_RSLT_CONF_SD0"
   group.long 0x320--0x323 "MDM_HI0_CH8_RSLT_CONF_SD0 (at 0x90400320)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_CONF_SD1"
   group.long 0x720--0x723 "MDM_HI0_CH8_RSLT_CONF_SD1 (at 0x90400720)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_CONF_SD2"
   group.long 0xb20--0xb23 "MDM_HI0_CH8_RSLT_CONF_SD2 (at 0x90400b20)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_RSLT_CONF_SD3"
   group.long 0xf20--0xf23 "MDM_HI0_CH8_RSLT_CONF_SD3 (at 0x90400f20)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_RSLT_CONF_SDs"
  tree "MDM_HI0_CH9_RSLT_CONF_SD0"
   group.long 0x324--0x327 "MDM_HI0_CH9_RSLT_CONF_SD0 (at 0x90400324)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_CONF_SD1"
   group.long 0x724--0x727 "MDM_HI0_CH9_RSLT_CONF_SD1 (at 0x90400724)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_CONF_SD2"
   group.long 0xb24--0xb27 "MDM_HI0_CH9_RSLT_CONF_SD2 (at 0x90400b24)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_RSLT_CONF_SD3"
   group.long 0xf24--0xf27 "MDM_HI0_CH9_RSLT_CONF_SD3 (at 0x90400f24)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_RSLT_CONF_SDs"
  tree "MDM_HI0_CH10_RSLT_CONF_SD0"
   group.long 0x328--0x32b "MDM_HI0_CH10_RSLT_CONF_SD0 (at 0x90400328)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_CONF_SD1"
   group.long 0x728--0x72b "MDM_HI0_CH10_RSLT_CONF_SD1 (at 0x90400728)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_CONF_SD2"
   group.long 0xb28--0xb2b "MDM_HI0_CH10_RSLT_CONF_SD2 (at 0x90400b28)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_RSLT_CONF_SD3"
   group.long 0xf28--0xf2b "MDM_HI0_CH10_RSLT_CONF_SD3 (at 0x90400f28)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_RSLT_CONF_SDs"
  tree "MDM_HI0_CH11_RSLT_CONF_SD0"
   group.long 0x32c--0x32f "MDM_HI0_CH11_RSLT_CONF_SD0 (at 0x9040032c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_CONF_SD1"
   group.long 0x72c--0x72f "MDM_HI0_CH11_RSLT_CONF_SD1 (at 0x9040072c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_CONF_SD2"
   group.long 0xb2c--0xb2f "MDM_HI0_CH11_RSLT_CONF_SD2 (at 0x90400b2c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_RSLT_CONF_SD3"
   group.long 0xf2c--0xf2f "MDM_HI0_CH11_RSLT_CONF_SD3 (at 0x90400f2c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_RSLT_CONF_SDs"
  tree "MDM_HI0_CH12_RSLT_CONF_SD0"
   group.long 0x330--0x333 "MDM_HI0_CH12_RSLT_CONF_SD0 (at 0x90400330)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_CONF_SD1"
   group.long 0x730--0x733 "MDM_HI0_CH12_RSLT_CONF_SD1 (at 0x90400730)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_CONF_SD2"
   group.long 0xb30--0xb33 "MDM_HI0_CH12_RSLT_CONF_SD2 (at 0x90400b30)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_RSLT_CONF_SD3"
   group.long 0xf30--0xf33 "MDM_HI0_CH12_RSLT_CONF_SD3 (at 0x90400f30)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_RSLT_CONF_SDs"
  tree "MDM_HI0_CH13_RSLT_CONF_SD0"
   group.long 0x334--0x337 "MDM_HI0_CH13_RSLT_CONF_SD0 (at 0x90400334)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_CONF_SD1"
   group.long 0x734--0x737 "MDM_HI0_CH13_RSLT_CONF_SD1 (at 0x90400734)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_CONF_SD2"
   group.long 0xb34--0xb37 "MDM_HI0_CH13_RSLT_CONF_SD2 (at 0x90400b34)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_RSLT_CONF_SD3"
   group.long 0xf34--0xf37 "MDM_HI0_CH13_RSLT_CONF_SD3 (at 0x90400f34)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_RSLT_CONF_SDs"
  tree "MDM_HI0_CH14_RSLT_CONF_SD0"
   group.long 0x338--0x33b "MDM_HI0_CH14_RSLT_CONF_SD0 (at 0x90400338)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_CONF_SD1"
   group.long 0x738--0x73b "MDM_HI0_CH14_RSLT_CONF_SD1 (at 0x90400738)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_CONF_SD2"
   group.long 0xb38--0xb3b "MDM_HI0_CH14_RSLT_CONF_SD2 (at 0x90400b38)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_RSLT_CONF_SD3"
   group.long 0xf38--0xf3b "MDM_HI0_CH14_RSLT_CONF_SD3 (at 0x90400f38)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_RSLT_CONF_SDs"
  tree "MDM_HI0_CH15_RSLT_CONF_SD0"
   group.long 0x33c--0x33f "MDM_HI0_CH15_RSLT_CONF_SD0 (at 0x9040033c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_CONF_SD1"
   group.long 0x73c--0x73f "MDM_HI0_CH15_RSLT_CONF_SD1 (at 0x9040073c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_CONF_SD2"
   group.long 0xb3c--0xb3f "MDM_HI0_CH15_RSLT_CONF_SD2 (at 0x90400b3c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_RSLT_CONF_SD3"
   group.long 0xf3c--0xf3f "MDM_HI0_CH15_RSLT_CONF_SD3 (at 0x90400f3c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRQ_EN                         = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_STATUS_SDs"
 tree "MDM_HI0_CH0_STATUS_SDs"
  tree "MDM_HI0_CH0_STATUS_SD0"
   group.long 0x200--0x203 "MDM_HI0_CH0_STATUS_SD0 (at 0x90400200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_STATUS_SD1"
   group.long 0x600--0x603 "MDM_HI0_CH0_STATUS_SD1 (at 0x90400600) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_STATUS_SD2"
   group.long 0xa00--0xa03 "MDM_HI0_CH0_STATUS_SD2 (at 0x90400a00) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH0_STATUS_SD3"
   group.long 0xe00--0xe03 "MDM_HI0_CH0_STATUS_SD3 (at 0x90400e00) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH1_STATUS_SDs"
  tree "MDM_HI0_CH1_STATUS_SD0"
   group.long 0x204--0x207 "MDM_HI0_CH1_STATUS_SD0 (at 0x90400204) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_STATUS_SD1"
   group.long 0x604--0x607 "MDM_HI0_CH1_STATUS_SD1 (at 0x90400604) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_STATUS_SD2"
   group.long 0xa04--0xa07 "MDM_HI0_CH1_STATUS_SD2 (at 0x90400a04) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_STATUS_SD3"
   group.long 0xe04--0xe07 "MDM_HI0_CH1_STATUS_SD3 (at 0x90400e04) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH2_STATUS_SDs"
  tree "MDM_HI0_CH2_STATUS_SD0"
   group.long 0x208--0x20b "MDM_HI0_CH2_STATUS_SD0 (at 0x90400208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_STATUS_SD1"
   group.long 0x608--0x60b "MDM_HI0_CH2_STATUS_SD1 (at 0x90400608) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_STATUS_SD2"
   group.long 0xa08--0xa0b "MDM_HI0_CH2_STATUS_SD2 (at 0x90400a08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_STATUS_SD3"
   group.long 0xe08--0xe0b "MDM_HI0_CH2_STATUS_SD3 (at 0x90400e08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH3_STATUS_SDs"
  tree "MDM_HI0_CH3_STATUS_SD0"
   group.long 0x20c--0x20f "MDM_HI0_CH3_STATUS_SD0 (at 0x9040020c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_STATUS_SD1"
   group.long 0x60c--0x60f "MDM_HI0_CH3_STATUS_SD1 (at 0x9040060c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_STATUS_SD2"
   group.long 0xa0c--0xa0f "MDM_HI0_CH3_STATUS_SD2 (at 0x90400a0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_STATUS_SD3"
   group.long 0xe0c--0xe0f "MDM_HI0_CH3_STATUS_SD3 (at 0x90400e0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH4_STATUS_SDs"
  tree "MDM_HI0_CH4_STATUS_SD0"
   group.long 0x210--0x213 "MDM_HI0_CH4_STATUS_SD0 (at 0x90400210) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_STATUS_SD1"
   group.long 0x610--0x613 "MDM_HI0_CH4_STATUS_SD1 (at 0x90400610) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_STATUS_SD2"
   group.long 0xa10--0xa13 "MDM_HI0_CH4_STATUS_SD2 (at 0x90400a10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_STATUS_SD3"
   group.long 0xe10--0xe13 "MDM_HI0_CH4_STATUS_SD3 (at 0x90400e10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH5_STATUS_SDs"
  tree "MDM_HI0_CH5_STATUS_SD0"
   group.long 0x214--0x217 "MDM_HI0_CH5_STATUS_SD0 (at 0x90400214) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_STATUS_SD1"
   group.long 0x614--0x617 "MDM_HI0_CH5_STATUS_SD1 (at 0x90400614) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_STATUS_SD2"
   group.long 0xa14--0xa17 "MDM_HI0_CH5_STATUS_SD2 (at 0x90400a14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_STATUS_SD3"
   group.long 0xe14--0xe17 "MDM_HI0_CH5_STATUS_SD3 (at 0x90400e14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH6_STATUS_SDs"
  tree "MDM_HI0_CH6_STATUS_SD0"
   group.long 0x218--0x21b "MDM_HI0_CH6_STATUS_SD0 (at 0x90400218) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
