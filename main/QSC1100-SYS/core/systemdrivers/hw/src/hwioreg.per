    bitfld.long 0x0 0x2--0x2 "  [    2]   FS0                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RST                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RS                             = " "0 (STOP),1 (RUN) "
  tree.end
  tree "USB_OTG_HS_USBSTS"
   group.long 0x144--0x147 "USB_OTG_HS_USBSTS (at 0x80016144) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   ULPI_INTR                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1e 1 "  [30:26]   RESERVED_BITS31_26             = "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   TI1                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   TI0                            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RESERVED_BITS23_20             = "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   UPI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UAI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   RESERVED_BIT17                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NAKI                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   AS                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PS                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RCL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   HCH                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   ULPII                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   RESERVED_BIT9                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SLI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SRI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   URI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   AAI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SEI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FRI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PCI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UEI                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UI                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_USBINTR"
   group.long 0x148--0x14b "USB_OTG_HS_USBINTR (at 0x80016148) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   ULPI_INTR_EN                   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x1a--0x1e 1 "  [30:26]   RESERVED_BITS31_26             = "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   TIE1                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   TIE0                           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RESERVED_BITS23_20             = "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   UPIE                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UAIE                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   RESERVED_BIT17                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   NAKE                           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xb--0xf 1 "  [15:11]   RESERVED_BITS15_11             = "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   ULPIE                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   RESERVED_BIT9                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SLE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SRE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   URE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   AAE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SEE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FRE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PCE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UEE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UE                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_FRINDEX"
   group.long 0x14c--0x14f "USB_OTG_HS_FRINDEX (at 0x8001614c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xe--0x1f 1 "  [31:14]   RESERVED_BITS31_14             = "
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   FRINDEX                        = "
  tree.end
  tree "USB_OTG_HS_PERIODICLISTBASE"
   group.long 0x154--0x157 "USB_OTG_HS_PERIODICLISTBASE (at 0x80016154) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   PERBASE                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   RESERVED_BITS11_0              = "
  tree.end
  tree "USB_OTG_HS_DEVICEADDR"
   group.long 0x154--0x157 "USB_OTG_HS_DEVICEADDR (at 0x80016154) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   USBADR                         = "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   USBADRA                        = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESERVED_BITS23_0              = "
  tree.end
  tree "USB_OTG_HS_ASYNCLISTADDR"
   group.long 0x158--0x15b "USB_OTG_HS_ASYNCLISTADDR (at 0x80016158) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x5--0x1f 1 "  [31: 5]   ASYBASE                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RESERVED_BITS4_0               = "
  tree.end
  tree "USB_OTG_HS_ENDPOINTLISTADDR"
   group.long 0x158--0x15b "USB_OTG_HS_ENDPOINTLISTADDR (at 0x80016158) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xb--0x1f 1 "  [31:11]   EPBASE                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   RESERVED_BITS10_0              = "
  tree.end
  tree "USB_OTG_HS_TTCTRL"
   group.long 0x15c--0x15f "USB_OTG_HS_TTCTRL (at 0x8001615c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   TTHA                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RESERVED_BITS23_0              = "
  tree.end
  tree "USB_OTG_HS_BURSTSIZE"
   group.long 0x160--0x163 "USB_OTG_HS_BURSTSIZE (at 0x80016160) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS31_16             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   TXPBURST                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RXPBURST                       = "
  tree.end
  tree "USB_OTG_HS_TXFILLTUNING"
   group.long 0x164--0x167 "USB_OTG_HS_TXFILLTUNING (at 0x80016164) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   RESERVED_BITS31_22             = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   TXFIFOTHRES                    = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BITS15_13             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   TXSCHHEALTH                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TXSCHOH                        = "
  tree.end
  tree "USB_OTG_HS_ULPI_VIEWPORT"
   group.long 0x170--0x173 "USB_OTG_HS_ULPI_VIEWPORT (at 0x80016170) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   ULPIWU                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   ULPIRUN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d "  [   29]   ULPIRW                         = " "0 (READ),1 (WRITE) "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RESERVED_BIT28                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b "  [   27]   ULPISS                         = " "0 (IN_ANOTHER_STATE),1 (NORMAL_SYNC_STATE) "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   ULPIPORT                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   ULPIADDR                       = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   ULPIDATRD                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ULPIDATWR                      = "
  tree.end
  tree "USB_OTG_HS_ENDPTNAK"
   group.long 0x178--0x17b "USB_OTG_HS_ENDPTNAK (at 0x80016178) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPTN                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPRN                           = "
  tree.end
  tree "USB_OTG_HS_ENDPTNAKEN"
   group.long 0x17c--0x17f "USB_OTG_HS_ENDPTNAKEN (at 0x8001617c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPTNE                          = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPRNE                          = "
  tree.end
  tree "USB_OTG_HS_PORTSC"
   group.long 0x184--0x187 "USB_OTG_HS_PORTSC (at 0x80016184) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   PTS                            = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   STS                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   PTW                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1b "  [27:26]   PSPD                           = " "0 (FULL_SPEED),1 (LOW_SPEED),2 (HIGH_SPEED),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   RESERVED_BIT25                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   PFSC                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   PHCD                           = " "0 (ENABLE_THE_PHY_CLOCK),1 (DISABLE_THE_PHY_CLOCK) "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   WKOC                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   WKDS                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   WKCN                           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PTC                            = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   PIC                            = " "0 (PORT_INDICATORS_ARE_OFF),1 (AMBER),2 (GREEN),3 (reserved) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PO                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PP                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   LS                             = " "0 (SE0),1 (K_STATE),2 (J_STATE),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HSP                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PR                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   SUSP                           = " "0 (reserved),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   FPR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OCC                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   OCA                            = " "0 (THIS_PORT_DOES_NOT_HAVE_AN_OVER_CURRENT_CONDITION),1 (THIS_PORT_CURRENTLY_HAS_AN_OVER_CURRENT_CONDITION) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   PEC                            = " "0 (NO_CHANGE),1 (PORT_ENABLED_DISABLED_STATUS_HAS_CHANGED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PE                             = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CSC                            = " "0 (NO_CHANGE),1 (CHANGE_IN_CURRENT_CONNECT_STATUS) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CCS                            = " "0 (NOT_ATTACHED),1 (ATTACHED) "
  tree.end
  tree "USB_OTG_HS_OTGSC"
   group.long 0x1a4--0x1a7 "USB_OTG_HS_OTGSC (at 0x800161a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   DPIE                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   1MSE                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BSEIE                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   BSVIE                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   ASVIE                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   AVVIE                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   IDIE                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   DPIS                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   1MSS                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BSEIS                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   BSVIS                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   ASVIS                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   AVVIS                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   IDIS                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DPS                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   1MST                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BSE                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   BSV                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   ASV                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   AVV                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   ID                             = " "0 (A_DEVICE),1 (B_DEVICE) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   HABA                           = " "0 (DISABLED),1 (ENABLE_AUTOMATIC_B_DISCONNECT_TO_A_CONNECT_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   HADP                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   IDPU                           = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   DP                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OT                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   HAAR                           = " "0 (DISABLED),1 (ENABLE_AUTOMATIC_RESET_AFTER_CONNECT_ON_HOST_PORT) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   VC                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VD                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_USBMODE"
   group.long 0x1a8--0x1ab "USB_OTG_HS_USBMODE (at 0x800161a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x6--0x1f 1 "  [31: 6]   RESERVED_BITS31_6              = "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   VBPS                           = " "0 (OUTPUT_IS_0),1 (OUTPUT_IS_1) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   SDIS                           = " "0 (INACTIVE),1 (ACTIVE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   SLOM                           = " "0 (SETUP_LOCKOUTS_ON),1 (SETUP_LOCKOUTS_OFF) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   ES                             = " "0 (LITTLE_ENDIAN),1 (BIG_ENDIAN_FIRST_BYTE_REFERENCED_IN_MOST_SIGNIFICANT_BYTE_OF_A_32_BIT_WORD) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CM                             = " "0 (IDLE_DEFAULT_FOR_COMBINATION_HOST_DEVICE),1 (reserved),2 (DEVICE_CONTROLLER_DEFAULT_FOR_DEVICE_ONLY_CONTROLLER),3 (HOST_CONTROLLER_DEFAULT_FOR_HOST_ONLY_CONTROLLER) "
  tree.end
  tree "USB_OTG_HS_ENPDTSETUPSTAT"
   group.long 0x1ac--0x1af "USB_OTG_HS_ENPDTSETUPSTAT (at 0x800161ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS31_16             = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   ENDPTSETUPSTAT                 = "
  tree.end
  tree "USB_OTG_HS_ENDPTPRIME"
   group.long 0x1b0--0x1b3 "USB_OTG_HS_ENDPTPRIME (at 0x800161b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   PETB                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PERB                           = "
  tree.end
  tree "USB_OTG_HS_ENDPTFLUSH"
   group.long 0x1b4--0x1b7 "USB_OTG_HS_ENDPTFLUSH (at 0x800161b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   FETB                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FERB                           = "
  tree.end
  tree "USB_OTG_HS_ENDPTSTAT"
   group.long 0x1b8--0x1bb "USB_OTG_HS_ENDPTSTAT (at 0x800161b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   ETBR                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   ERBR                           = "
  tree.end
  tree "USB_OTG_HS_ENDPTCOMPLETE"
   group.long 0x1bc--0x1bf "USB_OTG_HS_ENDPTCOMPLETE (at 0x800161bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   ETCE                           = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   ERCE                           = "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL0"
   group.long 0x1c0--0x1c3 "USB_OTG_HS_ENDPTCTRL0 (at 0x800161c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (reserved),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   RESERVED_BITS22_20             = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (reserved),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   RESERVED_BIT17                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (reserved),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   RESERVED_BITS6_4               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (reserved),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESERVED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
 tree "USB_OTG_HS_ENDPTCTRLn"
  tree "USB_OTG_HS_ENDPTCTRL1"
   group.long 0x1c0--0x1c3 "USB_OTG_HS_ENDPTCTRL1 (at 0x800161c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL2"
   group.long 0x1c4--0x1c7 "USB_OTG_HS_ENDPTCTRL2 (at 0x800161c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL3"
   group.long 0x1c8--0x1cb "USB_OTG_HS_ENDPTCTRL3 (at 0x800161c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL4"
   group.long 0x1cc--0x1cf "USB_OTG_HS_ENDPTCTRL4 (at 0x800161cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL5"
   group.long 0x1d0--0x1d3 "USB_OTG_HS_ENDPTCTRL5 (at 0x800161d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL6"
   group.long 0x1d4--0x1d7 "USB_OTG_HS_ENDPTCTRL6 (at 0x800161d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL7"
   group.long 0x1d8--0x1db "USB_OTG_HS_ENDPTCTRL7 (at 0x800161d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL8"
   group.long 0x1dc--0x1df "USB_OTG_HS_ENDPTCTRL8 (at 0x800161dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL9"
   group.long 0x1e0--0x1e3 "USB_OTG_HS_ENDPTCTRL9 (at 0x800161e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL10"
   group.long 0x1e4--0x1e7 "USB_OTG_HS_ENDPTCTRL10 (at 0x800161e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL11"
   group.long 0x1e8--0x1eb "USB_OTG_HS_ENDPTCTRL11 (at 0x800161e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL12"
   group.long 0x1ec--0x1ef "USB_OTG_HS_ENDPTCTRL12 (at 0x800161ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL13"
   group.long 0x1f0--0x1f3 "USB_OTG_HS_ENDPTCTRL13 (at 0x800161f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL14"
   group.long 0x1f4--0x1f7 "USB_OTG_HS_ENDPTCTRL14 (at 0x800161f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
  tree "USB_OTG_HS_ENDPTCTRL15"
   group.long 0x1f8--0x1fb "USB_OTG_HS_ENDPTCTRL15 (at 0x800161f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   TXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   TXR                            = " "0 (reserved),1 (RESET_PID_SEQUENCE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   TXI                            = " "0 (PID_SEQUENCING_ENABLED),1 (PID_SEQUENCING_DISABLED) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   RESERVED_BIT20                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   TXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   TXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   RXE                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RXR                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   RXI                            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESERVED_BIT4                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXT                            = " "0 (CONTROL),1 (ISOCHRONOUS),2 (BULK),3 (INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   RXD                            = " "0 (DUAL_PORT_MEMORY_BUFFER_DMA_ENGINE),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RXS                            = " "0 (END_POINT_OK),1 (END_POINT_STALLED) "
  tree.end
 tree.end
tree.end

base ad:0x80034000
tree "WDOG_SLP"
  tree "SLEEP_XTAL_TIMER_0_COUNT"
   group.long 0x0--0x3 "SLEEP_XTAL_TIMER_0_COUNT (at 0x80034000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP_XTAL_TIMER_1_COUNT"
   group.long 0x4--0x7 "SLEEP_XTAL_TIMER_1_COUNT (at 0x80034004)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP_XTAL_TIMETICK_COUNT"
   group.long 0x8--0xb "SLEEP_XTAL_TIMETICK_COUNT (at 0x80034008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "WDOG_STATUS"
   group.long 0x18--0x1b "WDOG_STATUS (at 0x80034018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0x10 1 "  [16: 3]   WDOG_COUNT                     = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_CNT_RESET_STATUS          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   AUTOKICK_EN                    = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RESET_STATUS                   = " "0 (RESIN_N_RESET),1 (WATCHDOG_RESET) "
  tree.end
  tree "SLEEP_XTAL_TIMER_0_ENABLE"
   group.long 0xb0--0xb3 "SLEEP_XTAL_TIMER_0_ENABLE (at 0x800340b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_STATUS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENABLE                         = " "0 (RESET),1 (ENABLE) "
  tree.end
  tree "SLEEP_XTAL_TIMER_1_ENABLE"
   group.long 0xb4--0xb7 "SLEEP_XTAL_TIMER_1_ENABLE (at 0x800340b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_STATUS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENABLE                         = " "0 (RESET),1 (ENABLE) "
  tree.end
  tree "SLEEP_XTAL_TIMER_0_MATCH_VAL"
   group.long 0xb8--0xbb "SLEEP_XTAL_TIMER_0_MATCH_VAL (at 0x800340b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SYNC_STATUS                    = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP_XTAL_TIMER_1_MATCH_VAL"
   group.long 0xbc--0xbf "SLEEP_XTAL_TIMER_1_MATCH_VAL (at 0x800340bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SYNC_STATUS                    = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP_XTAL_TIMETICK_MATCH_VAL_STATUS"
   group.long 0xc0--0xc3 "SLEEP_XTAL_TIMETICK_MATCH_VAL_STATUS (at 0x800340c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_STATUS                    = " "0,1 "
  tree.end
  tree "SLEEP_XTAL_TIMETICK_MATCH_VAL"
   group.long 0xc4--0xc7 "SLEEP_XTAL_TIMETICK_MATCH_VAL (at 0x800340c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "WDOG_EXPIRED_WIDTH"
   group.long 0xc8--0xcb "WDOG_EXPIRED_WIDTH (at 0x800340c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SYNC_STATUS                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   DATA                           = "
  tree.end
  tree "WDOG_TEST_LOAD_STATUS"
   group.long 0xcc--0xcf "WDOG_TEST_LOAD_STATUS (at 0x800340cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_STATUS                    = " "0,1 "
  tree.end
  tree "WDOG_TEST"
   group.long 0xd4--0xd7 "WDOG_TEST (at 0x800340d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SYNC_STATUS                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   WDOG_TEST_CNT                  = "
  tree.end
tree.end
