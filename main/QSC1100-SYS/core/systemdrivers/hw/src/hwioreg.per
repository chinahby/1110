    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_STATUS_SD1"
   group.long 0x618--0x61b "MDM_HI0_CH6_STATUS_SD1 (at 0x90400618) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_STATUS_SD2"
   group.long 0xa18--0xa1b "MDM_HI0_CH6_STATUS_SD2 (at 0x90400a18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_STATUS_SD3"
   group.long 0xe18--0xe1b "MDM_HI0_CH6_STATUS_SD3 (at 0x90400e18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH7_STATUS_SDs"
  tree "MDM_HI0_CH7_STATUS_SD0"
   group.long 0x21c--0x21f "MDM_HI0_CH7_STATUS_SD0 (at 0x9040021c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_STATUS_SD1"
   group.long 0x61c--0x61f "MDM_HI0_CH7_STATUS_SD1 (at 0x9040061c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_STATUS_SD2"
   group.long 0xa1c--0xa1f "MDM_HI0_CH7_STATUS_SD2 (at 0x90400a1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_STATUS_SD3"
   group.long 0xe1c--0xe1f "MDM_HI0_CH7_STATUS_SD3 (at 0x90400e1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH8_STATUS_SDs"
  tree "MDM_HI0_CH8_STATUS_SD0"
   group.long 0x220--0x223 "MDM_HI0_CH8_STATUS_SD0 (at 0x90400220) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_STATUS_SD1"
   group.long 0x620--0x623 "MDM_HI0_CH8_STATUS_SD1 (at 0x90400620) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_STATUS_SD2"
   group.long 0xa20--0xa23 "MDM_HI0_CH8_STATUS_SD2 (at 0x90400a20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_STATUS_SD3"
   group.long 0xe20--0xe23 "MDM_HI0_CH8_STATUS_SD3 (at 0x90400e20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH9_STATUS_SDs"
  tree "MDM_HI0_CH9_STATUS_SD0"
   group.long 0x224--0x227 "MDM_HI0_CH9_STATUS_SD0 (at 0x90400224) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_STATUS_SD1"
   group.long 0x624--0x627 "MDM_HI0_CH9_STATUS_SD1 (at 0x90400624) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_STATUS_SD2"
   group.long 0xa24--0xa27 "MDM_HI0_CH9_STATUS_SD2 (at 0x90400a24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_STATUS_SD3"
   group.long 0xe24--0xe27 "MDM_HI0_CH9_STATUS_SD3 (at 0x90400e24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH10_STATUS_SDs"
  tree "MDM_HI0_CH10_STATUS_SD0"
   group.long 0x228--0x22b "MDM_HI0_CH10_STATUS_SD0 (at 0x90400228) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_STATUS_SD1"
   group.long 0x628--0x62b "MDM_HI0_CH10_STATUS_SD1 (at 0x90400628) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_STATUS_SD2"
   group.long 0xa28--0xa2b "MDM_HI0_CH10_STATUS_SD2 (at 0x90400a28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_STATUS_SD3"
   group.long 0xe28--0xe2b "MDM_HI0_CH10_STATUS_SD3 (at 0x90400e28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH11_STATUS_SDs"
  tree "MDM_HI0_CH11_STATUS_SD0"
   group.long 0x22c--0x22f "MDM_HI0_CH11_STATUS_SD0 (at 0x9040022c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_STATUS_SD1"
   group.long 0x62c--0x62f "MDM_HI0_CH11_STATUS_SD1 (at 0x9040062c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_STATUS_SD2"
   group.long 0xa2c--0xa2f "MDM_HI0_CH11_STATUS_SD2 (at 0x90400a2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_STATUS_SD3"
   group.long 0xe2c--0xe2f "MDM_HI0_CH11_STATUS_SD3 (at 0x90400e2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH12_STATUS_SDs"
  tree "MDM_HI0_CH12_STATUS_SD0"
   group.long 0x230--0x233 "MDM_HI0_CH12_STATUS_SD0 (at 0x90400230) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_STATUS_SD1"
   group.long 0x630--0x633 "MDM_HI0_CH12_STATUS_SD1 (at 0x90400630) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_STATUS_SD2"
   group.long 0xa30--0xa33 "MDM_HI0_CH12_STATUS_SD2 (at 0x90400a30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_STATUS_SD3"
   group.long 0xe30--0xe33 "MDM_HI0_CH12_STATUS_SD3 (at 0x90400e30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH13_STATUS_SDs"
  tree "MDM_HI0_CH13_STATUS_SD0"
   group.long 0x234--0x237 "MDM_HI0_CH13_STATUS_SD0 (at 0x90400234) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_STATUS_SD1"
   group.long 0x634--0x637 "MDM_HI0_CH13_STATUS_SD1 (at 0x90400634) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_STATUS_SD2"
   group.long 0xa34--0xa37 "MDM_HI0_CH13_STATUS_SD2 (at 0x90400a34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_STATUS_SD3"
   group.long 0xe34--0xe37 "MDM_HI0_CH13_STATUS_SD3 (at 0x90400e34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH14_STATUS_SDs"
  tree "MDM_HI0_CH14_STATUS_SD0"
   group.long 0x238--0x23b "MDM_HI0_CH14_STATUS_SD0 (at 0x90400238) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_STATUS_SD1"
   group.long 0x638--0x63b "MDM_HI0_CH14_STATUS_SD1 (at 0x90400638) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_STATUS_SD2"
   group.long 0xa38--0xa3b "MDM_HI0_CH14_STATUS_SD2 (at 0x90400a38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_STATUS_SD3"
   group.long 0xe38--0xe3b "MDM_HI0_CH14_STATUS_SD3 (at 0x90400e38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CH15_STATUS_SDs"
  tree "MDM_HI0_CH15_STATUS_SD0"
   group.long 0x23c--0x23f "MDM_HI0_CH15_STATUS_SD0 (at 0x9040023c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_STATUS_SD1"
   group.long 0x63c--0x63f "MDM_HI0_CH15_STATUS_SD1 (at 0x9040063c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_STATUS_SD2"
   group.long 0xa3c--0xa3f "MDM_HI0_CH15_STATUS_SD2 (at 0x90400a3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_STATUS_SD3"
   group.long 0xe3c--0xe3f "MDM_HI0_CH15_STATUS_SD3 (at 0x90400e3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RSLT_FIFO_CNTR                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   CMD_PTR_FIFO_CNTR              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   CMD_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RSLT_VLD                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_PTR_RDY                    = " "0,1 "
  tree.end
 tree.end
 tree.end
 tree "MDM_HI0_CHn_CONF"
  tree "MDM_HI0_CH0_CONF"
   group.long 0x240--0x243 "MDM_HI0_CH0_CONF (at 0x90400240) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH1_CONF"
   group.long 0x244--0x247 "MDM_HI0_CH1_CONF (at 0x90400244) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH2_CONF"
   group.long 0x248--0x24b "MDM_HI0_CH2_CONF (at 0x90400248) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH3_CONF"
   group.long 0x24c--0x24f "MDM_HI0_CH3_CONF (at 0x9040024c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH4_CONF"
   group.long 0x250--0x253 "MDM_HI0_CH4_CONF (at 0x90400250) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH5_CONF"
   group.long 0x254--0x257 "MDM_HI0_CH5_CONF (at 0x90400254) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH6_CONF"
   group.long 0x258--0x25b "MDM_HI0_CH6_CONF (at 0x90400258) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH7_CONF"
   group.long 0x25c--0x25f "MDM_HI0_CH7_CONF (at 0x9040025c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH8_CONF"
   group.long 0x260--0x263 "MDM_HI0_CH8_CONF (at 0x90400260) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH9_CONF"
   group.long 0x264--0x267 "MDM_HI0_CH9_CONF (at 0x90400264) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH10_CONF"
   group.long 0x268--0x26b "MDM_HI0_CH10_CONF (at 0x90400268) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH11_CONF"
   group.long 0x26c--0x26f "MDM_HI0_CH11_CONF (at 0x9040026c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH12_CONF"
   group.long 0x270--0x273 "MDM_HI0_CH12_CONF (at 0x90400270) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH13_CONF"
   group.long 0x274--0x277 "MDM_HI0_CH13_CONF (at 0x90400274) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH14_CONF"
   group.long 0x278--0x27b "MDM_HI0_CH14_CONF (at 0x90400278) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
  tree "MDM_HI0_CH15_CONF"
   group.long 0x27c--0x27f "MDM_HI0_CH15_CONF (at 0x9040027c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   OTHER_CH_BLK_MASK              = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   RSLT_CONF_SHADOW_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MPU_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PERM_MPU_CONF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RESERVED_BIT8                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FLUSH_RSLT_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IRQ_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEC_DOMAIN                     = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRIORITY                       = "
  tree.end
 tree.end
 tree "MDM_HI0_CHn_DBG_0"
  tree "MDM_HI0_CH0_DBG_0"
   group.long 0x280--0x283 "MDM_HI0_CH0_DBG_0 (at 0x90400280) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH1_DBG_0"
   group.long 0x284--0x287 "MDM_HI0_CH1_DBG_0 (at 0x90400284)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH2_DBG_0"
   group.long 0x288--0x28b "MDM_HI0_CH2_DBG_0 (at 0x90400288)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH3_DBG_0"
   group.long 0x28c--0x28f "MDM_HI0_CH3_DBG_0 (at 0x9040028c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH4_DBG_0"
   group.long 0x290--0x293 "MDM_HI0_CH4_DBG_0 (at 0x90400290)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH5_DBG_0"
   group.long 0x294--0x297 "MDM_HI0_CH5_DBG_0 (at 0x90400294)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH6_DBG_0"
   group.long 0x298--0x29b "MDM_HI0_CH6_DBG_0 (at 0x90400298)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH7_DBG_0"
   group.long 0x29c--0x29f "MDM_HI0_CH7_DBG_0 (at 0x9040029c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH8_DBG_0"
   group.long 0x2a0--0x2a3 "MDM_HI0_CH8_DBG_0 (at 0x904002a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH9_DBG_0"
   group.long 0x2a4--0x2a7 "MDM_HI0_CH9_DBG_0 (at 0x904002a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH10_DBG_0"
   group.long 0x2a8--0x2ab "MDM_HI0_CH10_DBG_0 (at 0x904002a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH11_DBG_0"
   group.long 0x2ac--0x2af "MDM_HI0_CH11_DBG_0 (at 0x904002ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH12_DBG_0"
   group.long 0x2b0--0x2b3 "MDM_HI0_CH12_DBG_0 (at 0x904002b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH13_DBG_0"
   group.long 0x2b4--0x2b7 "MDM_HI0_CH13_DBG_0 (at 0x904002b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH14_DBG_0"
   group.long 0x2b8--0x2bb "MDM_HI0_CH14_DBG_0 (at 0x904002b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
  tree "MDM_HI0_CH15_DBG_0"
   group.long 0x2bc--0x2bf "MDM_HI0_CH15_DBG_0 (at 0x904002bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REQ_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_ENG_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CMD_PTR_FIFO_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ERROR                          = " "0,1 "
  tree.end
 tree.end
 tree "MDM_HI0_CHn_DBG_1"
  tree "MDM_HI0_CH0_DBG_1"
   group.long 0x2c0--0x2c3 "MDM_HI0_CH0_DBG_1 (at 0x904002c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH1_DBG_1"
   group.long 0x2c4--0x2c7 "MDM_HI0_CH1_DBG_1 (at 0x904002c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH2_DBG_1"
   group.long 0x2c8--0x2cb "MDM_HI0_CH2_DBG_1 (at 0x904002c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH3_DBG_1"
   group.long 0x2cc--0x2cf "MDM_HI0_CH3_DBG_1 (at 0x904002cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH4_DBG_1"
   group.long 0x2d0--0x2d3 "MDM_HI0_CH4_DBG_1 (at 0x904002d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH5_DBG_1"
   group.long 0x2d4--0x2d7 "MDM_HI0_CH5_DBG_1 (at 0x904002d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH6_DBG_1"
   group.long 0x2d8--0x2db "MDM_HI0_CH6_DBG_1 (at 0x904002d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH7_DBG_1"
   group.long 0x2dc--0x2df "MDM_HI0_CH7_DBG_1 (at 0x904002dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH8_DBG_1"
   group.long 0x2e0--0x2e3 "MDM_HI0_CH8_DBG_1 (at 0x904002e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH9_DBG_1"
   group.long 0x2e4--0x2e7 "MDM_HI0_CH9_DBG_1 (at 0x904002e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH10_DBG_1"
   group.long 0x2e8--0x2eb "MDM_HI0_CH10_DBG_1 (at 0x904002e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH11_DBG_1"
   group.long 0x2ec--0x2ef "MDM_HI0_CH11_DBG_1 (at 0x904002ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH12_DBG_1"
   group.long 0x2f0--0x2f3 "MDM_HI0_CH12_DBG_1 (at 0x904002f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH13_DBG_1"
   group.long 0x2f4--0x2f7 "MDM_HI0_CH13_DBG_1 (at 0x904002f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH14_DBG_1"
   group.long 0x2f8--0x2fb "MDM_HI0_CH14_DBG_1 (at 0x904002f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_CH15_DBG_1"
   group.long 0x2fc--0x2ff "MDM_HI0_CH15_DBG_1 (at 0x904002fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
 tree.end
 tree "MDM_HI0_CIn_CONF"
  tree "MDM_HI0_CI0_CONF"
   group.long 0x390--0x393 "MDM_HI0_CI0_CONF (at 0x90400390) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI1_CONF"
   group.long 0x394--0x397 "MDM_HI0_CI1_CONF (at 0x90400394)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI2_CONF"
   group.long 0x398--0x39b "MDM_HI0_CI2_CONF (at 0x90400398)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI3_CONF"
   group.long 0x39c--0x39f "MDM_HI0_CI3_CONF (at 0x9040039c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI4_CONF"
   group.long 0x3a0--0x3a3 "MDM_HI0_CI4_CONF (at 0x904003a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI5_CONF"
   group.long 0x3a4--0x3a7 "MDM_HI0_CI5_CONF (at 0x904003a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI6_CONF"
   group.long 0x3a8--0x3ab "MDM_HI0_CI6_CONF (at 0x904003a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
  tree "MDM_HI0_CI7_CONF"
   group.long 0x3ac--0x3af "MDM_HI0_CI7_CONF (at 0x904003ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RANGE_END                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RANGE_START                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CI_WEIGHT                      = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BURST_LEN                  = "
  tree.end
 tree.end
 tree "MDM_HI0_CIn_DBG_ERR"
  tree "MDM_HI0_CI0_DBG_ERR"
   group.long 0x3b0--0x3b3 "MDM_HI0_CI0_DBG_ERR (at 0x904003b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI1_DBG_ERR"
   group.long 0x3b4--0x3b7 "MDM_HI0_CI1_DBG_ERR (at 0x904003b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI2_DBG_ERR"
   group.long 0x3b8--0x3bb "MDM_HI0_CI2_DBG_ERR (at 0x904003b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI3_DBG_ERR"
   group.long 0x3bc--0x3bf "MDM_HI0_CI3_DBG_ERR (at 0x904003bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI4_DBG_ERR"
   group.long 0x3c0--0x3c3 "MDM_HI0_CI4_DBG_ERR (at 0x904003c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI5_DBG_ERR"
   group.long 0x3c4--0x3c7 "MDM_HI0_CI5_DBG_ERR (at 0x904003c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI6_DBG_ERR"
   group.long 0x3c8--0x3cb "MDM_HI0_CI6_DBG_ERR (at 0x904003c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
  tree "MDM_HI0_CI7_DBG_ERR"
   group.long 0x3cc--0x3cf "MDM_HI0_CI7_DBG_ERR (at 0x904003cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DATA_BUS_ERR                   = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CMD_BUS_ERR                    = "
  tree.end
 tree.end
  tree "MDM_HI0_CRCI_DBG"
   group.long 0x3d0--0x3d3 "MDM_HI0_CRCI_DBG (at 0x904003d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CRCI_RST                       = "
  tree.end
  tree "MDM_HI0_CRCI_STATUS"
   group.long 0x3d4--0x3d7 "MDM_HI0_CRCI_STATUS (at 0x904003d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CRCI_RDY                       = "
  tree.end
  tree "MDM_HI0_GP_CTL"
   group.long 0x3d8--0x3db "MDM_HI0_GP_CTL (at 0x904003d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS_31_16            = "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   CI6_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CI5_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CI4_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CI3_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CI2_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   CI1_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CI0_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CI_HALT_REQ                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   CI1_ADDR_OFFSET                = "
  tree.end
  tree "MDM_HI0_GP_STATUS"
   group.long 0x3dc--0x3df "MDM_HI0_GP_STATUS (at 0x904003dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS_31_2             = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CI_HALT_ACK                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CI_IDLE                        = " "0,1 "
  tree.end
  tree "MDM_HI0_GLBL_DBG_CMD_ENG"
   group.long 0x3e0--0x3e3 "MDM_HI0_GLBL_DBG_CMD_ENG (at 0x904003e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_GLBL_DBG_REQ_ENG"
   group.long 0x3e4--0x3e7 "MDM_HI0_GLBL_DBG_REQ_ENG (at 0x904003e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_GLBL_DBG_XFR_ENG"
   group.long 0x3e8--0x3eb "MDM_HI0_GLBL_DBG_XFR_ENG (at 0x904003e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DBG_STATE                      = "
  tree.end
  tree "MDM_HI0_GLBL_DBG_CHAN_BLK"
   group.long 0x3ec--0x3ef "MDM_HI0_GLBL_DBG_CHAN_BLK (at 0x904003ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CHAN_BLK_MASK                  = "
  tree.end
  tree "MDM_HI0_GLBL_DBG_CHAN_BLK_CLR"
   group.long 0x3f0--0x3f3 "MDM_HI0_GLBL_DBG_CHAN_BLK_CLR (at 0x904003f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CHAN_BLK_CLR_CHAN_NNUM         = "
  tree.end
  tree "MDM_HI0_GLBL_DBG_TEST_SEL"
   group.long 0x3f4--0x3f7 "MDM_HI0_GLBL_DBG_TEST_SEL (at 0x904003f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TEST_BUS_SEL                   = "
  tree.end
tree.end
tree "EBI"
base ad:0x80026000
tree "EBI1_REGS"
  tree "EBI1_CFG"
   group.long 0x0--0x3 "EBI1_CFG (at 0x80026000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   ADV_UB_LB_HIGH                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   BURST_INCR_CFG                 = " "0 (4_WORD_BURSTS),1 (8_WORD_BURSTS),2 (16_WORD_BURSTS),3 (SINGLE_ACCESS) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SDRAM_CTLR_MODE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   FBCLK_PAD_FB_ENA               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   FBCLK_PGM_DLY_CTL              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PWRSAVE_MODE                   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x2--0x6 1 "  [ 6: 2]   RESERVED_BITS6_2               = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WAIT_N_PGM_DLY_CTL             = " "0,1,2,3 "
  tree.end
 tree "EBI1_CSn_CFG0"
  tree "EBI1_CS0_CFG0"
   group.long 0xc--0xf "EBI1_CS0_CFG0 (at 0x8002600c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HOLD_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI1_CS1_CFG0"
   group.long 0x14--0x17 "EBI1_CS1_CFG0 (at 0x80026014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HOLD_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI1_CS2_CFG0"
   group.long 0x1c--0x1f "EBI1_CS2_CFG0 (at 0x8002601c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HOLD_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI1_CS3_CFG0"
   group.long 0x24--0x27 "EBI1_CS3_CFG0 (at 0x80026024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HOLD_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
 tree.end
 tree "EBI1_CSn_CFG1"
  tree "EBI1_CS0_CFG1"
   group.long 0x10--0x13 "EBI1_CS0_CFG1 (at 0x80026010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   CS_REFRESH_MODE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_32B),2 (8_WORD_PAGE_32B),3 (16_WORD_PAGE_32B),4 (reserved),5 (64_WORD_PAGE_32B),6 (128_WORD_PAGE_32B),7 (256_WORD_PAGE_32B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   X32_DEVICE_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI1_CS1_CFG1"
   group.long 0x18--0x1b "EBI1_CS1_CFG1 (at 0x80026018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   CS_REFRESH_MODE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_32B),2 (8_WORD_PAGE_32B),3 (16_WORD_PAGE_32B),4 (reserved),5 (64_WORD_PAGE_32B),6 (128_WORD_PAGE_32B),7 (256_WORD_PAGE_32B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   X32_DEVICE_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI1_CS2_CFG1"
   group.long 0x20--0x23 "EBI1_CS2_CFG1 (at 0x80026020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   CS_REFRESH_MODE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_32B),2 (8_WORD_PAGE_32B),3 (16_WORD_PAGE_32B),4 (reserved),5 (64_WORD_PAGE_32B),6 (128_WORD_PAGE_32B),7 (256_WORD_PAGE_32B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   X32_DEVICE_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI1_CS3_CFG1"
   group.long 0x28--0x2b "EBI1_CS3_CFG1 (at 0x80026028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   CS_REFRESH_MODE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_32B),2 (8_WORD_PAGE_32B),3 (16_WORD_PAGE_32B),4 (reserved),5 (64_WORD_PAGE_32B),6 (128_WORD_PAGE_32B),7 (256_WORD_PAGE_32B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   X32_DEVICE_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
 tree.end
  tree "EBI1_AHB_RD_PRIORITY"
   group.long 0x30--0x33 "EBI1_AHB_RD_PRIORITY (at 0x80026030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa "  [   10]   PP_RR_SEL                      = " "0 (PROGRAMMABLE_PRIORITY),1 (ROUND_ROBIN) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1),2 (AHB_PORT2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AHB2_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AHB1_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AHB0_PP_PRIORITY               = " "0,1,2,3 "
  tree.end
  tree "EBI1_AHB_WR_PRIORITY"
   group.long 0x34--0x37 "EBI1_AHB_WR_PRIORITY (at 0x80026034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   HI_TH_MRK_FL_PRIORITY          = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PORT2_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT1_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   PORT0_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BITS10                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1),2 (AHB_PORT2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AHB2_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AHB1_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AHB0_PP_PRIORITY               = " "0,1,2,3 "
  tree.end
  tree "EBI1_BUFC_CFG"
   group.long 0x3c--0x3f "EBI1_BUFC_CFG (at 0x8002603c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   FLUSH_IDLE_CNT                 = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   FLUSH_ALL_BUF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   RESERVED_BIT22                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   BUF_MODE                       = " "0 (SINGLE_BUFFER_MODE),1 (DUAL_BUFFER_MODE),2 (MULTI_BUFFER_MODE_ALL_8_BUFFERS_AVAILABLE),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HIGH_TH_MARK                   = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOW_TH_MARK                    = "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   RESERVED_BITS11_4              = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IMM_FL_CS                      = "
  tree.end
  tree "EBI1_BUFC_STATUS"
   group.long 0x40--0x43 "EBI1_BUFC_STATUS (at 0x80026040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BUF_MODE_SWITCH_ERROR_1        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   BUF_MODE_SWITCH_ERROR_0        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BUFF_EMPTY                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   CSX_CONTENTS_IN_BUFFER         = "
  tree.end
  tree "EBI1_BUFC_PROF_COUNT_CFG"
   group.long 0x44--0x47 "EBI1_BUFC_PROF_COUNT_CFG (at 0x80026044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   EBI1_BUFC_PROF_COUNT2_SAT_LOCK_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   EBI1_BUFC_PROF_COUNT1_SAT_LOCK_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   EBI1_BUFC_PROF_COUNT0_SAT_LOCK_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   EBI1_BUFC_PROF_COUNT_SW_TRIG   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   EBI1_BUFC_PROF_COUNT2_CFG      = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   EBI1_BUFC_PROF_COUNT1_CFG      = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EBI1_BUFC_PROF_COUNT0_CFG      = "
  tree.end
  tree "EBI1_PSRAM_REFRESH_CFG"
   group.long 0x4c--0x4f "EBI1_PSRAM_REFRESH_CFG (at 0x8002604c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xc--0x17 1 "  [23:12]   REFRESH_INTERVAL               = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   SELF_REFRESH_RECOVERY          = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   EXT_REFRESH_RECOVERY           = "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_REFRESH_ENA                = " "0,1 "
  tree.end
  tree "EBI1_BUFC_PROF_COUNT0"
   group.long 0x54--0x57 "EBI1_BUFC_PROF_COUNT0 (at 0x80026054)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EBI1_BUFC_PROF_COUNT_0         = "
  tree.end
  tree "EBI1_BUFC_PROF_COUNT1"
   group.long 0x58--0x5b "EBI1_BUFC_PROF_COUNT1 (at 0x80026058)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EBI1_BUFC_PROF_COUNT_1         = "
  tree.end
  tree "EBI1_BUFC_PROF_COUNT2"
   group.long 0x5c--0x5f "EBI1_BUFC_PROF_COUNT2 (at 0x8002605c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   EBI1_BUFC_PROF_COUNT_2         = "
  tree.end
  tree "EBI1_DEBUG_BUS_CFG0"
   group.long 0x60--0x63 "EBI1_DEBUG_BUS_CFG0 (at 0x80026060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   RESERVED_BIT31_30              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   EBI1_MEMC_AHB_IF_DBG_BLK_SEL   = " "0 (EBI1_PORT0_AHB_IF),1 (EBI1_PORT1_AHB_IF),2 (EBI1_PORT2_AHB_IF),3 (EBI1_PORT3_AHB_IF) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   EBI1_MEMC_AHB_IF_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   EBI1_MEMC_AHB_IF_DBG_D15_D0_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   EBI1_MEMC_AHB_IF_DBG_SWAP      = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EBI1_RW_ARB_MUX_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EBI1_RW_ARB_MUX_DBG_D15_D0_EN  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   EBI1_RW_ARB_MUX_DBG_SWAP       = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   EBI1_WRITE_ARB_MUX_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   EBI1_WRITE_ARB_MUX_DBG_D15_D0_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   EBI1_WRITE_ARB_MUX_DBG_SWAP    = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   EBI1_READ_ARB_MUX_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   EBI1_READ_ARB_MUX_DBG_D15_D0_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   EBI1_READ_ARB_MUX_DBG_SWAP     = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   COAL_BUFC_DBG_BLK_SEL          = " "0 (COAL_BUFFC),1 (COALESCING_BUFFER_CONTROLLER),2 (READ_INTERFACE),3 (BUFFER_FLUSH_CONTROLLER),4 (reserved),5 (reserved),6 (reserved),7 (256_WORD_PAGE_32B) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COAL_BUFC_DBG_MODE             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   COAL_BUFC_DBG_D31_D16_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   COAL_BUFC_DBG_D15_D0_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   COAL_BUFC_DBG_SWAP             = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
  tree "EBI1_DEBUG_BUS_CFG1"
   group.long 0x64--0x67 "EBI1_DEBUG_BUS_CFG1 (at 0x80026064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   EBI1_2X_XLTR_DBG_SEL           = " "0 (INPUT_DEBUG_SIGNALS),1 (OUTPUT_DEBUG_SIGNALS),2 (INTERNAL_CONTROL_DEBUG_SIGNALS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   EBI1_2X_XLTR_DBG_D31_D16_EN    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EBI1_2X_XLTR_DBG_D15_D0_EN     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   EBI1_2X_XLTR_DBG_SWAP          = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   EBI1_XMEMC_DBG_SEL             = " "0 (ASYNC_INTERFACE_DEBUG_SIGNALS),1 (PAGE_INTERFACE_DEBUG_SIGNALS),2 (BURST_INTERFACE_DEBUG_SIGNALS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI1_XMEMC_DBG_D31_D16_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EBI1_XMEMC_DBG_D15_D0_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EBI1_XMEMC_DBG_SWAP            = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
 tree "EBI1_DEBUG_WORDn_BUFC"
  tree "EBI1_DEBUG_WORD0_BUFC"
   group.long 0x70--0x73 "EBI1_DEBUG_WORD0_BUFC (at 0x80026070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD1_BUFC"
   group.long 0x74--0x77 "EBI1_DEBUG_WORD1_BUFC (at 0x80026074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD2_BUFC"
   group.long 0x78--0x7b "EBI1_DEBUG_WORD2_BUFC (at 0x80026078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD3_BUFC"
   group.long 0x7c--0x7f "EBI1_DEBUG_WORD3_BUFC (at 0x8002607c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD4_BUFC"
   group.long 0x80--0x83 "EBI1_DEBUG_WORD4_BUFC (at 0x80026080)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD5_BUFC"
   group.long 0x84--0x87 "EBI1_DEBUG_WORD5_BUFC (at 0x80026084)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD6_BUFC"
   group.long 0x88--0x8b "EBI1_DEBUG_WORD6_BUFC (at 0x80026088)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI1_DEBUG_WORD7_BUFC"
   group.long 0x8c--0x8f "EBI1_DEBUG_WORD7_BUFC (at 0x8002608c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
 tree.end
 tree "EBI1_DEBUG_WORD_ENn_BUFC"
  tree "EBI1_DEBUG_WORD_EN0_BUFC"
   group.long 0x90--0x93 "EBI1_DEBUG_WORD_EN0_BUFC (at 0x80026090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN1_BUFC"
   group.long 0x94--0x97 "EBI1_DEBUG_WORD_EN1_BUFC (at 0x80026094) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN2_BUFC"
   group.long 0x98--0x9b "EBI1_DEBUG_WORD_EN2_BUFC (at 0x80026098) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN3_BUFC"
   group.long 0x9c--0x9f "EBI1_DEBUG_WORD_EN3_BUFC (at 0x8002609c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN4_BUFC"
   group.long 0xa0--0xa3 "EBI1_DEBUG_WORD_EN4_BUFC (at 0x800260a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN5_BUFC"
   group.long 0xa4--0xa7 "EBI1_DEBUG_WORD_EN5_BUFC (at 0x800260a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN6_BUFC"
   group.long 0xa8--0xab "EBI1_DEBUG_WORD_EN6_BUFC (at 0x800260a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI1_DEBUG_WORD_EN7_BUFC"
   group.long 0xac--0xaf "EBI1_DEBUG_WORD_EN7_BUFC (at 0x800260ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
 tree.end
  tree "EBI1_DEBUG_BUFC_CFG"
   group.long 0xb0--0xb3 "EBI1_DEBUG_BUFC_CFG (at 0x800260b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   DISABLE_FLUSH_REQ              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BUFF_SEL                       = "
  tree.end
  tree "EBI1_DEBUG_BUFC_TAG_RD0"
   group.long 0xbc--0xbf "EBI1_DEBUG_BUFC_TAG_RD0 (at 0x800260bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x16 1 "  [22: 0]   TAG_HADDR                      = "
  tree.end
  tree "EBI1_DEBUG_BUFC_TAG_RD1"
   group.long 0xc0--0xc3 "EBI1_DEBUG_BUFC_TAG_RD1 (at 0x800260c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TAG_HSEL                       = "
  tree.end
  tree "EBI1_BUFC_PROFILING_CFG"
   group.long 0xc4--0xc7 "EBI1_BUFC_PROFILING_CFG (at 0x800260c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   HW_CNTR3_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   HW_CNTR2_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HW_CNTR1_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_CNTR0_MODE                  = "
  tree.end
 tree "EBI1_CSn_CFG2"
  tree "EBI1_CS0_CFG2"
   group.long 0xd0--0xd3 "EBI1_CS0_CFG2 (at 0x800260d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI1_CS1_CFG2"
   group.long 0xd4--0xd7 "EBI1_CS1_CFG2 (at 0x800260d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI1_CS2_CFG2"
   group.long 0xd8--0xdb "EBI1_CS2_CFG2 (at 0x800260d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI1_CS3_CFG2"
   group.long 0xdc--0xdf "EBI1_CS3_CFG2 (at 0x800260dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x8 1 "  [ 8: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
 tree.end
  tree "EBI1_LCD_CFG"
   group.long 0xe0--0xe3 "EBI1_LCD_CFG (at 0x800260e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   LCD_RS_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LCD_RS_MODE                    = " "0 (LCD_RS_VAL_DRIVES_THE_EBI1_PIN_MUXED_WITH_LCD_RS),1 (BIT_20_OF_AHB_ADDRESS_DURING_THE_ACCESS),2 (BIT_19_OF_AHB_ADDRESS_DURING_THE_ACCESS),3 (BIT_18_OF_AHB_ADDRESS_DURING_THE_ACCESS) "
  tree.end
  tree "EBI1_2X_XLTR_CFG"
   group.long 0xf0--0xf3 "EBI1_2X_XLTR_CFG (at 0x800260f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   REGISTER_NSEQ_WR_MODE          = " "0,1 "
  tree.end
tree.end

base ad:0x80028000
tree "EBI2_REGS"
  tree "EBI2_CFG"
   group.long 0x0--0x3 "EBI2_CFG (at 0x80028000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   DM_CMD_REQ_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   PNAND_DM_REQ_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   PULSED_IRQ_ENA                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   PNAND_IRQ_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1b "  [27:26]   BURST_INCR_CFG                 = " "0 (4_WORD_BURSTS),1 (8_WORD_BURSTS),2 (16_WORD_BURSTS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   RESERVED_BIT25                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   ADV_UB_LB_HIGH                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x12--0x17 1 "  [23:18]   WAIT_N_PGM_DLY_CTL             = "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   NAND2_BUS_ENA                  = " "0 (EBI2_CS3_ON),1 (NAND_CS2_ON) "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   NAND_BUS_ENA                   = " "0 (EBI2_CS1_ON),1 (NAND_CS_ON) "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   EBI2_PRIORITY                  = " "0 (XMEM_CONTROLLER),1 (NAND_CONTROLLER) "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   FBCLK_PAD_FB_ENA               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   FBCLK_PGM_DLY_CTL              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PWRSAVE_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   FBCLK_PAD_FNDLY_ENA            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PGM_DLY_CTL                    = "
  tree.end
  tree "LCD_CFG0"
   group.long 0x4--0x7 "LCD_CFG0 (at 0x80028004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   LCD_CS_SETUP                   = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   LCD_RECOVERY                   = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LCD_HOLD_WR                    = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LCD_HOLD_RD                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LCD_WAIT_WR                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   LCD_WAIT_RD                    = "
  tree.end
  tree "LCD_CFG1"
   group.long 0x8--0xb "LCD_CFG1 (at 0x80028008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   LCD_MUX_ADDR_DATA_ENA          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   LCD_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   LCD_D_ON_UB_LB                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_18_OR_24_BIT_ENA           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   LCD_RS_VAL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x19 "  [25:24]   LCD_RS_MODE                    = " "0 (LCD_RS_VAL_DRIVES_LCD_RS_PIN),1 (BIT_20_OF_AHB_ADDRESS_DURING_THE_ACCESS),2 (BIT_19_OF_AHB_ADDRESS_DURING_THE_ACCESS),3 (BIT_18_OF_AHB_ADDRESS_DURING_THE_ACCESS) "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LCD_E_SETUP_WRITE              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LCD_E_SETUP_READ               = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   LCD_INTERFACE_TYPE             = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   LCD_E_HIGH_WRITE               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_BYTE_DEVICE_ENA            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LCD_E_HIGH_READ                = "
  tree.end
 tree "EBI2_CSn_CFG0"
  tree "EBI2_CS0_CFG0"
   group.long 0xc--0xf "EBI2_CS0_CFG0 (at 0x8002800c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_WR                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI2_CS1_CFG0"
   group.long 0x18--0x1b "EBI2_CS1_CFG0 (at 0x80028018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_WR                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI2_CS2_CFG0"
   group.long 0x24--0x27 "EBI2_CS2_CFG0 (at 0x80028024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_WR                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "EBI2_CS3_CFG0"
   group.long 0x30--0x33 "EBI2_CS3_CFG0 (at 0x80028030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_WR                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
 tree.end
 tree "EBI2_CSn_CFG1"
  tree "EBI2_CS0_CFG1"
   group.long 0x10--0x13 "EBI2_CS0_CFG1 (at 0x80028010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MUX_ADDR_DATA_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_16B),2 (8_WORD_PAGE_16B),3 (16_WORD_PAGE_16B),4 (reserved),5 (64_WORD_PAGE_16B),6 (128_WORD_PAGE_16B),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYTE_DEVICE_ENA                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI2_CS1_CFG1"
   group.long 0x1c--0x1f "EBI2_CS1_CFG1 (at 0x8002801c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MUX_ADDR_DATA_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_16B),2 (8_WORD_PAGE_16B),3 (16_WORD_PAGE_16B),4 (reserved),5 (64_WORD_PAGE_16B),6 (128_WORD_PAGE_16B),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYTE_DEVICE_ENA                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI2_CS2_CFG1"
   group.long 0x28--0x2b "EBI2_CS2_CFG1 (at 0x80028028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MUX_ADDR_DATA_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_16B),2 (8_WORD_PAGE_16B),3 (16_WORD_PAGE_16B),4 (reserved),5 (64_WORD_PAGE_16B),6 (128_WORD_PAGE_16B),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYTE_DEVICE_ENA                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI2_CS3_CFG1"
   group.long 0x34--0x37 "EBI2_CS3_CFG1 (at 0x80028034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MUX_ADDR_DATA_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   XTRA_ADDR_SETUP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_16B),2 (8_WORD_PAGE_16B),3 (16_WORD_PAGE_16B),4 (reserved),5 (64_WORD_PAGE_16B),6 (128_WORD_PAGE_16B),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYTE_DEVICE_ENA                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
 tree.end
 tree "EBI2_CSn_CFG2"
  tree "EBI2_CS0_CFG2"
   group.long 0x14--0x17 "EBI2_CS0_CFG2 (at 0x80028014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BIT11_10              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI2_CS1_CFG2"
   group.long 0x20--0x23 "EBI2_CS1_CFG2 (at 0x80028020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BIT11_10              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI2_CS2_CFG2"
   group.long 0x2c--0x2f "EBI2_CS2_CFG2 (at 0x8002802c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BIT11_10              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
  tree "EBI2_CS3_CFG2"
   group.long 0x38--0x3b "EBI2_CS3_CFG2 (at 0x80028038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DYN_BL_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BIT11_10              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x9 1 "  [ 9: 4]   TWOCYC_UPPER_ADDR              = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   XTRA_CS_ADV_SETUP              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWOCYC_MSB_CS_DIS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWOCYC_OE_HOLD_ENA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TWOCYC_OE_ACTIVE               = " "0,1 "
  tree.end
 tree.end
  tree "ETM_GPIO2_CFG0"
   group.long 0x4c--0x4f "ETM_GPIO2_CFG0 (at 0x8002804c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RECOVERY                       = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_WR                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INIT_LATENCY_WR                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   INIT_LATENCY_RD                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   WAIT_WR                        = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WAIT_RD                        = "
  tree.end
  tree "ETM_GPIO2_CFG1"
   group.long 0x50--0x53 "ETM_GPIO2_CFG1 (at 0x80028050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MUX_ADDR_DATA_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   OPT_ADDR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   TWO_CYC_ADDR_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   LCD_RS_ENA                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   HOLD_RD                        = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   PAGE_SIZE                      = " "0 (reserved),1 (4_WORD_PAGE_16B),2 (8_WORD_PAGE_16B),3 (16_WORD_PAGE_16B),4 (reserved),5 (64_WORD_PAGE_16B),6 (128_WORD_PAGE_16B),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   IGN_WAIT_FOR_WR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   IGN_WAIT_FOR_RD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ADV_OE_RECOVERY                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PRECHARGE_CYC                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   WR_PRECHARGE                   = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYTE_DEVICE_ENA                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   WE_TIMING                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_HOLD_ENA                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WRAP8_RD_MODE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BURST_WR_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BURST_RD_ENA                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAGE_WR_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAGE_RD_ENA                    = " "0,1 "
  tree.end
  tree "EBI2_DEBUG_BUS_CFG"
   group.long 0x54--0x57 "EBI2_DEBUG_BUS_CFG (at 0x80028054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   EBI2_ARB_DBG_D31_D16_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   EBI2_ARB_DBG_D15_D0_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   EBI2_ARB_DBG_SWAP              = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x16--0x17 "  [23:22]   RESERVED_BIT22_23              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   EBI2_XMEMC_DBG_SEL             = " "0 (ASYNC_INTERFACE_DEBUG_SIGNALS),1 (PAGE_INTERFACE_DEBUG_SIGNALS),2 (BURST_INTERFACE_DEBUG_SIGNALS),3 (MISCELLANEOUS_SIGNALS) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   EBI2_XMEMC_DBG_D31_D16_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   EBI2_XMEMC_DBG_D15_D0_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   EBI2_XMEMC_DBG_SWAP            = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   EBI2_MEMC_AHB_IF_DBG_BLK_SEL   = " "0 (EBI2_PORT0_AHB_IF),1 (EBI2_PORT1_AHB_IF),2 (EBI2_PORT2_AHB_IF),3 (EBI2_PORT3_AHB_IF) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   EBI2_MEMC_AHB_IF_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EBI2_MEMC_AHB_IF_DBG_D15_D0_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   EBI2_MEMC_AHB_IF_DBG_SWAP      = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "EBI2_PROFILING_CFG"
   group.long 0x58--0x5b "EBI2_PROFILING_CFG (at 0x80028058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   EBI2_HW_CNTR_EN2_CFG           = " "0 (FEATURE_DISABLED),1 (HIGH_WHEN_EBI2_XMEM_CTLR_IS_IN_IDLE_STATE_OR_NAND_CONTROLLER_IS_IDLE),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   EBI2_HW_CNTR_EN1_CFG           = " "0 (FEATURE_DISABLED),1 (HIGH_WHEN_NAND_CONTROLLER_IS_IDLE),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EBI2_HW_CNTR_EN0_CFG           = " "0 (FEATURE_DISABLED),1 (HIGH_WHEN_EBI2_XMEM_CTLR_IS_IN_IDLE_STATE),2 (reserved),3 (reserved) "
  tree.end
  tree "EBI2_SWBM_AHB_PRIORITY"
   group.long 0x80--0x83 "EBI2_SWBM_AHB_PRIORITY (at 0x80028080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RESERVED_BITS14                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PORT2_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT1_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   PORT0_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BITS10                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1),2 (AHB_PORT2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AHB2_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AHB1_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AHB0_PP_PRIORITY               = " "0,1,2,3 "
  tree.end
  tree "EBI2_SWBM_STATUS"
   group.long 0x88--0x8b "EBI2_SWBM_STATUS (at 0x80028088)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SWBM_IDLE                      = " "0,1 "
  tree.end
  tree "EBI2_SWBM_DEBUG_BUS_CFG"
   group.long 0x8c--0x8f "EBI2_SWBM_DEBUG_BUS_CFG (at 0x8002808c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AHB_ARB_MUX_DBG_D31_D16_EN     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   AHB_ARB_MUX_DBG_D15_D0_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   AHB_ARB_MUX_DBG_SWAP           = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SWBM_DBG_D31_D16_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SWBM_DBG_D15_D0_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SWBM_DBG_SWAP                  = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
  tree "EBI2_CBC_AHB_RD_PRIORITY"
   group.long 0xb0--0xb3 "EBI2_CBC_AHB_RD_PRIORITY (at 0x800280b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa "  [   10]   PP_RR_SEL                      = " "0 (PROGRAMMABLE_PRIORITY),1 (ROUND_ROBIN) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1),2 (AHB_PORT2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AHB2_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AHB1_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AHB0_PP_PRIORITY               = " "0,1,2,3 "
  tree.end
  tree "EBI2_CBC_AHB_WR_PRIORITY"
   group.long 0xb4--0xb7 "EBI2_CBC_AHB_WR_PRIORITY (at 0x800280b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   HI_TH_MRK_FL_PRIORITY          = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PORT2_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT1_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   PORT0_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BITS10                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1),2 (AHB_PORT2),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AHB2_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AHB1_PP_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AHB0_PP_PRIORITY               = " "0,1,2,3 "
  tree.end
  tree "EBI2_CBC_BUFC_CFG"
   group.long 0xb8--0xbb "EBI2_CBC_BUFC_CFG (at 0x800280b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   FLUSH_IDLE_CNT                 = "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   FLUSH_ALL_BUF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   RESERVED_BIT22                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   BUF_MODE                       = " "0 (SINGLE_BUFFER_MODE),1 (DUAL_BUFFER_MODE),2 (MULTI_BUFFER_MODE_ALL_BUFFERS_AVAILABLE),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   HIGH_TH_MARK                   = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOW_TH_MARK                    = "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   RESERVED_BITS11_10             = " "0,1,2,3 "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   IMM_FL_CS                      = "
  tree.end
  tree "EBI2_CBC_BUFC_STATUS"
   group.long 0xbc--0xbf "EBI2_CBC_BUFC_STATUS (at 0x800280bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BUF_MODE_SWITCH_ERROR_1        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   BUF_MODE_SWITCH_ERROR_0        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BUFF_EMPTY                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   CSX_CONTENTS_IN_BUFFER         = "
  tree.end
  tree "EBI2_CBC_PRF_CNT_CFG"
   group.long 0xc0--0xc3 "EBI2_CBC_PRF_CNT_CFG (at 0x800280c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   CNT2_SAT_LOCK_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CNT1_SAT_LOCK_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CNT0_SAT_LOCK_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SW_TRIG                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   CNT2_CFG                       = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CNT1_CFG                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CNT0_CFG                       = "
  tree.end
  tree "EBI2_CBC_PRF_CNT0"
   group.long 0xc4--0xc7 "EBI2_CBC_PRF_CNT0 (at 0x800280c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CNT0                           = "
  tree.end
  tree "EBI2_CBC_PRF_CNT1"
   group.long 0xc8--0xcb "EBI2_CBC_PRF_CNT1 (at 0x800280c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CNT1                           = "
  tree.end
  tree "EBI2_CBC_PRF_CNT2"
   group.long 0xcc--0xcf "EBI2_CBC_PRF_CNT2 (at 0x800280cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   CNT2                           = "
  tree.end
  tree "EBI2_CBC_DEBUG_BUS_CFG0"
   group.long 0xd0--0xd3 "EBI2_CBC_DEBUG_BUS_CFG0 (at 0x800280d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   RW_ARB_MUX_DBG_D31_D16_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   RW_ARB_MUX_DBG_D15_D0_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   RW_ARB_MUX_DBG_SWAP            = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   WR_ARB_MUX_DBG_D31_D16_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   WR_ARB_MUX_DBG_D15_D0_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   WR_ARB_MUX_DBG_SWAP            = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RD_ARB_MUX_DBG_D31_D16_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RD_ARB_MUX_DBG_D15_D0_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   RD_ARB_MUX_DBG_SWAP            = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   COAL_BUFC_DBG_BLK_SEL          = " "0 (COAL_BUFFC),1 (COALESCING_BUFFER_CONTROLLER),2 (READ_INTERFACE),3 (BUFFER_FLUSH_CONTROLLER),4 (reserved),5 (reserved),6 (reserved),7 (256_WORD_PAGE_16B) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COAL_BUFC_DBG_MODE             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   COAL_BUFC_DBG_D31_D16_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   COAL_BUFC_DBG_D15_D0_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   COAL_BUFC_DBG_SWAP             = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
 tree "EBI2_CBC_DEBUG_WORDn"
  tree "EBI2_CBC_DEBUG_WORD0"
   group.long 0xe0--0xe3 "EBI2_CBC_DEBUG_WORD0 (at 0x800280e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD1"
   group.long 0xe4--0xe7 "EBI2_CBC_DEBUG_WORD1 (at 0x800280e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD2"
   group.long 0xe8--0xeb "EBI2_CBC_DEBUG_WORD2 (at 0x800280e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD3"
   group.long 0xec--0xef "EBI2_CBC_DEBUG_WORD3 (at 0x800280ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD4"
   group.long 0xf0--0xf3 "EBI2_CBC_DEBUG_WORD4 (at 0x800280f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD5"
   group.long 0xf4--0xf7 "EBI2_CBC_DEBUG_WORD5 (at 0x800280f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD6"
   group.long 0xf8--0xfb "EBI2_CBC_DEBUG_WORD6 (at 0x800280f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD7"
   group.long 0xfc--0xff "EBI2_CBC_DEBUG_WORD7 (at 0x800280fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   BUFF_DATA                      = "
  tree.end
 tree.end
 tree "EBI2_CBC_DEBUG_WORD_ENn"
  tree "EBI2_CBC_DEBUG_WORD_EN0"
   group.long 0x100--0x103 "EBI2_CBC_DEBUG_WORD_EN0 (at 0x80028100)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN1"
   group.long 0x104--0x107 "EBI2_CBC_DEBUG_WORD_EN1 (at 0x80028104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN2"
   group.long 0x108--0x10b "EBI2_CBC_DEBUG_WORD_EN2 (at 0x80028108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN3"
   group.long 0x10c--0x10f "EBI2_CBC_DEBUG_WORD_EN3 (at 0x8002810c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN4"
   group.long 0x110--0x113 "EBI2_CBC_DEBUG_WORD_EN4 (at 0x80028110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN5"
   group.long 0x114--0x117 "EBI2_CBC_DEBUG_WORD_EN5 (at 0x80028114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN6"
   group.long 0x118--0x11b "EBI2_CBC_DEBUG_WORD_EN6 (at 0x80028118) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
  tree "EBI2_CBC_DEBUG_WORD_EN7"
   group.long 0x11c--0x11f "EBI2_CBC_DEBUG_WORD_EN7 (at 0x8002811c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   RESERVED_31_29                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   BYTE_EN_3_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_27_25                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYTE_EN_3                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   RESERVED_23_21                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BYTE_EN_2_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_19_17                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   BYTE_EN_2                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_15_13                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BYTE_EN_1_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_11_9                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYTE_EN_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYTE_EN_0_COPY                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYTE_EN_0                      = " "0,1 "
  tree.end
 tree.end
  tree "EBI2_CBC_DEBUG_CFG"
   group.long 0x120--0x123 "EBI2_CBC_DEBUG_CFG (at 0x80028120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   DISABLE_FLUSH_REQ              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BUFF_SEL                       = "
  tree.end
  tree "EBI2_CBC_DEBUG_TAG_RD0"
   group.long 0x124--0x127 "EBI2_CBC_DEBUG_TAG_RD0 (at 0x80028124)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x16 1 "  [22: 0]   TAG_HADDR                      = "
  tree.end
  tree "EBI2_CBC_DEBUG_TAG_RD1"
   group.long 0x128--0x12b "EBI2_CBC_DEBUG_TAG_RD1 (at 0x80028128)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   TAG_HSEL                       = "
  tree.end
  tree "EBI2_CBC_PRF_CFG"
   group.long 0x12c--0x12f "EBI2_CBC_PRF_CFG (at 0x8002812c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   HW_CNTR3_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   HW_CNTR2_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HW_CNTR1_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_CNTR0_MODE                  = "
  tree.end
tree.end
tree.end
tree "EFUSE"
base ad:0x80036000
tree "EFUSE"
  tree "EF_CHAIN_SEL"
   group.long 0x0--0x3 "EF_CHAIN_SEL (at 0x80036000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CHIP_ID_CHAIN_SEL              = " "0 (DO_NOT_SELECT_THIS_CHAIN),1 (SELECT_THIS_CHAIN) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CONFIG_CHAIN_SEL               = " "0 (DO_NOT_SELECT_THIS_CHAIN),1 (SELECT_THIS_CHAIN) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HW_KEY_CHAIN_SEL               = " "0 (DO_NOT_SELECT_THIS_CHAIN),1 (SELECT_CHAIN_MSB),2 (SELECT_CHAIN_LSB),3 (ILLEGAL_VALUE) "
  tree.end
  tree "EF_BLOW_TIMER"
   group.long 0x4--0x7 "EF_BLOW_TIMER (at 0x80036004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   BLOW_TIMER                     = "
  tree.end
  tree "EF_BLOW_VALUE"
   group.long 0x8--0xb "EF_BLOW_VALUE (at 0x80036008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BLOW_VALUE                     = "
  tree.end
  tree "EF_SHIFT_VALUE"
   group.long 0xc--0xf "EF_SHIFT_VALUE (at 0x8003600c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SHIFT_VAL                      = "
  tree.end
  tree "EF_STATUS"
   group.long 0x10--0x13 "EF_STATUS (at 0x80036010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FUSE_SENSE_TIMEOUT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   FUSE_SENSE_DONE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   STATUS_DONE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   STATUS_START                   = " "0,1 "
  tree.end
  tree "EF_PWR_CTL"
   group.long 0x14--0x17 "EF_PWR_CTL (at 0x80036014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   SEL_EFUSE_DBG_BUS              = " "0 (DISABLES_THE_EFUSE_DBG_BUS),1 (ENABLES_THE_EFUSE_DBG_BUS) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SW_VDD_4_BLOW_EN               = " "0 (TURN_ON_THE_VDD_4_BLOW),1 (TURN_OFF_THE_VDD_4_BLOW) "
  tree.end
  tree "EF_CONFIG_LSB"
   group.long 0x18--0x1b "EF_CONFIG_LSB (at 0x80036018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x4--0x1f 1 "  [31: 4]   OEM_HW_ID                      = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   SW_FUSE_PGM_DSBL               = " "0 (ENABLE),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   HW_KEY_PGM_DSBL                = " "0 (ENABLE),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CHIP_ID_DSBL                   = " "0 (ENABLE),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CONFIG_PGM_DSBL                = " "0 (ENABLE),1 (DISABLE) "
  tree.end
  tree "EF_CONFIG_MSB"
   group.long 0x1c--0x1f "EF_CONFIG_MSB (at 0x8003601c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SPARE_FUSE_BIT                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   TIC_DISABLE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   PBL_JTAG_DISABLE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   CLK_INCREASE_DISABLE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPARE_27                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   DISABLE_MODEM                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x16--0x19 1 "  [25:22]   V_SCALE                        = "
    textline ""
    bitfld.long 0x0 0x13--0x15 "  [21:19]   RF_PROCESS_MONITOR             = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   SPI_SLAVE_DISABLE              = " "0 (SPI_SLAVE_FUNC_ENABLED),1 (SPI_SLAVE_FUNC_DISABLED) "
    textline ""
    hexmask.long.byte 0x0 0xe--0x11 1 "  [17:14]   ARM9_RAM_ACC_CTRL              = "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SPARE_13                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SOFTWARE_CRASH_DEBUG           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   ARM9_JTAG_EN_N                 = " "0 (ALWAYS_ENABLE_ARM9_JTAG),1 (NORMAL_FUNCTIONAL_MODE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   SECURE_BOOT                    = " "0 (DO_NOT_FORCE_SBL_AUTHENTICATION),1 (FORCE_CODE_AUTHENTICATION) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   BOOT_FROM_ROM                  = " "0 (BOOT_FROM_EXTERNAL_MEMORY),1 (USE_BOOT_ROM_BOOT_LOADER) "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   DISABLE_153_KBPS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DISABLE_MULTIMEDIA             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ROOT_KEY_SELECT                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OEM_HW_ID                      = "
  tree.end
  tree "ENABLE_ARM9_JTAG"
   group.long 0x20--0x23 "ENABLE_ARM9_JTAG (at 0x80036020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENABLE_ARM9_JTAG               = " "0 (DISABLED),1 (ENABLED) "
  tree.end
tree.end

base ad:0x91000000
tree "EFUSE2"
  tree "RF_CAL_PART1"
   group.long 0xc00024--0xc00027 "RF_CAL_PART1 (at 0x91c00024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RF_CAL_PART1                   = "
  tree.end
  tree "RF_CAL_PART2"
   group.long 0xc00028--0xc0002b "RF_CAL_PART2 (at 0x91c00028)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RF_CAL_PART2                   = "
  tree.end
  tree "RF_CAL_PART3"
   group.long 0xc00020--0xc00023 "RF_CAL_PART3 (at 0x91c00020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   RF_CAL_PART3                   = " "0,1,2,3 "
  tree.end
tree.end
tree.end
tree "EMU"
base ad:0x90003300
tree "EMU_ANTRAM"
  tree "EMU_ANT_RAM_ADDR_VAL"
   group.long 0x0--0x3 "EMU_ANT_RAM_ADDR_VAL (at 0x90003300) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   ADDR                           = "
  tree.end
  tree "EMU_ANT_RAM_DATA"
   group.long 0x4--0x7 "EMU_ANT_RAM_DATA (at 0x90003304) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "EMU_ANT_RAM_RTCMATCH"
   group.long 0x8--0xb "EMU_ANT_RAM_RTCMATCH (at 0x90003308) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "EMU_ANT_RAM_CTL"
   group.long 0xc--0xf "EMU_ANT_RAM_CTL (at 0x9000330c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   QRC_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ANT_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   SAMPLE_SOURCE                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RX1_HDR_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RX1_GPS_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RX0_HDR_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX0_GPS_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "EMU_ANT_RAM_DEBUG_CTL"
   group.long 0x10--0x13 "EMU_ANT_RAM_DEBUG_CTL (at 0x90003310) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                            = "
  tree.end
  tree "EMU_ANT_RAM_GPO"
   group.long 0x14--0x17 "EMU_ANT_RAM_GPO (at 0x90003314) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                            = "
  tree.end
  tree "EMU_ANT_RAM_DEBUG2_CTL"
   group.long 0x18--0x1b "EMU_ANT_RAM_DEBUG2_CTL (at 0x90003318) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                            = "
  tree.end
  tree "EMU_RXFPGA_MODE_SEL"
   group.long 0x20--0x23 "EMU_RXFPGA_MODE_SEL (at 0x90003320) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TRK_LO_ADJ_SEL                 = " "0,1 "
  tree.end
  tree "EMU_QDSP_CTL_ADDR"
   group.long 0x24--0x27 "EMU_QDSP_CTL_ADDR (at 0x90003324) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MDSP_DECRYP_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MDSP_RESET                     = " "0,1 "
  tree.end
  tree "EMU_QDSP_PC_DEBIG"
   group.long 0x28--0x2b "EMU_QDSP_PC_DEBIG (at 0x90003328)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   QDSP_PC                        = "
  tree.end
  tree "EMU_USB_CTL"
   group.long 0x2c--0x2f "EMU_USB_CTL (at 0x9000332c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EMU_USB_MIC_CON                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EMU_USB_MIC_SPD                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EMU_USB_MIC_SUS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EMU_USB_MIC_SEL_N              = " "0,1 "
  tree.end
  tree "EMU_USB_DET"
   group.long 0x30--0x33 "EMU_USB_DET (at 0x90003330)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EMU_USB_DET                    = " "0,1 "
  tree.end
tree.end

base ad:0x90003000
tree "EMU_RXFPGA"
  tree "EMU_RX_FPGA_VERSION_RD"
   group.long 0x0--0x3 "EMU_RX_FPGA_VERSION_RD (at 0x90003000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
tree.end

base ad:0x90003200
tree "EMU_TDECFPGA"
  tree "EMU_TDEC_FPGA_VERSION_RD"
   group.long 0x0--0x3 "EMU_TDEC_FPGA_VERSION_RD (at 0x90003200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "EMU_TDEC_DBG_BUS_RD"
   group.long 0x4--0x7 "EMU_TDEC_DBG_BUS_RD (at 0x90003204)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "EMU_TDEC_DSP_PC_RD"
   group.long 0x8--0xb "EMU_TDEC_DSP_PC_RD (at 0x90003208)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   PC                             = "
  tree.end
  tree "EMU_TDEC_DSP_XMEMC_SIG_RD"
   group.long 0xc--0xf "EMU_TDEC_DSP_XMEMC_SIG_RD (at 0x9000320c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RD_DATA                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   WR_DATA                        = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BITS15_14             = " "0,1,2,3 "
    textline ""
    hexmask.long.word 0x0 0x2--0xd 1 "  [13: 2]   ADDR                           = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   WR_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CS                             = " "0,1 "
  tree.end
tree.end

base ad:0x90003100
tree "EMU_TXFPGA"
  tree "EMU_TX_FPGA_VERSION_RD"
   group.long 0x0--0x3 "EMU_TX_FPGA_VERSION_RD (at 0x90003100)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "EMU_TX_SYSTEM_MODE"
   group.long 0x4--0x7 "EMU_TX_SYSTEM_MODE (at 0x90003104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   TX_PUNCT_SEL                   = " "0 (IS_2000),1 (HDR),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PA_POWERUP_MODE                = " "0 (IS_2000),1 (HDR),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   PA_PUNCT_SEL                   = " "0 (IS_2000),1 (HDR),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PA_RANGE_SEL                   = " "0 (IS_2000),1 (HDR) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TX_AGC_ADJ_SEL                 = " "0 (IS_2000),1 (HDR),2 (reserved),3 (reserved) "
  tree.end
  tree "EMU_TX_GPIO_WR"
   group.long 0x8--0xb "EMU_TX_GPIO_WR (at 0x90003108)   (shadowed - Use hwio_shadow_ptr->EMU_TX_GPIO_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "EMU_TX_GPIO_STATUS_RD"
   group.long 0xc--0xf "EMU_TX_GPIO_STATUS_RD (at 0x9000310c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "EMU_TX_GPIO_OE"
   group.long 0x10--0x13 "EMU_TX_GPIO_OE (at 0x90003110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GPIO_OE                        = "
  tree.end
  tree "EMU_PA_ON_CTL"
   group.long 0x14--0x17 "EMU_PA_ON_CTL (at 0x90003114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYPASS_TX_SYNTH_LOCK           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_TX_PUNCT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TX_ON_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASS_PA_SYNTH_LOCK_RAW       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_PA_PUNCT_RAW            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UNUSED_BIT2                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BAND_SEL                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_ON_EN                       = " "0,1 "
  tree.end
  tree "EMU_PA_ON_STATUS_RD"
   group.long 0x18--0x1b "EMU_PA_ON_STATUS_RD (at 0x90003118)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   HDR_PA_PUNCT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   HDR_TX_PUNCT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_ON                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PA_PUNCT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PA_ON2                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_STATE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PA_ON                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UNUSED_BIT4                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   DFM_PAON_TXCTL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CDMA_FM_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TX_PUNCT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SYNTH_LOCK                     = " "0,1 "
  tree.end
tree.end
tree.end

base ad:0x90001800
tree "FL_SYM_BUFF"
  tree "FL_SYM_BUFF_MODE"
   group.long 0x0--0x3 "FL_SYM_BUFF_MODE (at 0x90001800) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL                       = " "0 (DEINTERLEAVER),1 (HDR_DEMOD),2 (PDCH_ENGINE),3 (MICRO_INTERFACE_OVERRIDE) "
  tree.end
  tree "FL_SYM_BUFF_CLK_CTL"
   group.long 0x4--0x7 "FL_SYM_BUFF_CLK_CTL (at 0x90001804) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CLK_LCG_EN                     = " "0 (SOFTWARE_CONTROL),1 (HARDWARE_CONTROL) "
  tree.end
  tree "FL_SYM_BUFF_CLK_OVERRIDE"
   group.long 0x8--0xb "FL_SYM_BUFF_CLK_OVERRIDE (at 0x90001808) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CLK_ENABLE                     = " "0 (LOCAL_CLOCK_IS_OFF),1 (LOCAL_CLOCK_IS_ON) "
  tree.end
  tree "FL_SYM_BUFF_CLK_STATUS_RD"
   group.long 0xc--0xf "FL_SYM_BUFF_CLK_STATUS_RD (at 0x9000180c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   HALTED                         = " "0 (CLOCK_IS_NOT_HALTED),1 (CLOCK_IS_HALTED) "
  tree.end
  tree "FL_SYM_BUFF_MEM_RD"
   group.long 0x14--0x17 "FL_SYM_BUFF_MEM_RD (at 0x90001814)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   RD_DATA                        = "
  tree.end
tree.end

base ad:0x90600000
tree "GACC"
  tree "GACC_DM_BYPASS"
   group.long 0x0--0x3 "GACC_DM_BYPASS (at 0x90600000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GACC_DM_BYPASS                 = " "0,1 "
  tree.end
  tree "GACC_CLK_CTL"
   group.long 0x4--0x7 "GACC_CLK_CTL (at 0x90600004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   GACC_HW_LCG_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   GACC_SW_CLK_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GACC_CLK_EN                    = " "0,1 "
  tree.end
  tree "GACC_TEST_BUS_OUT"
   group.long 0x8--0xb "GACC_TEST_BUS_OUT (at 0x90600008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GACC_AHB2HB_IDLE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GACC_WAIT_FOR_RTC              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GACC_INTF_IDLE_STATE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   GACC_READ_PEAK_WAIT_STATE      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   GACC_SP_CURRENT_STATE          = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GACC_CLK_IS_ON                 = " "0,1 "
  tree.end
  tree "GACC_RTC_WAIT_ALT"
   group.long 0x80000--0x80003 "GACC_RTC_WAIT_ALT (at 0x90680000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x19 "  [25:24]   GACC_RTC_SELECT                = " "0 (GPS),1 (CDMA),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_RTC_WAIT                  = "
  tree.end
  tree "GACC_START_ADDR_ALT"
   group.long 0x80004--0x80007 "GACC_START_ADDR_ALT (at 0x90680004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xc--0x17 1 "  [23:12]   GACC_ENERGY_ADDR               = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GACC_SAMPLE_ADDR               = "
  tree.end
  tree "GACC_COUNT_ALT"
   group.long 0x80008--0x8000b "GACC_COUNT_ALT (at 0x90680008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   GACC_ENERGY_ITER               = "
    textline ""
    hexmask.long.word 0x0 0xf--0x18 1 "  [24:15]   GACC_HYP_ITER                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   GACC_SAMP_ITER                 = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   GACC_FREQ_ITER                 = "
  tree.end
  tree "GACC_INCR_ALT"
   group.long 0x8000c--0x8000f "GACC_INCR_ALT (at 0x9068000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   GACC_SAMP_INCR_SAMP            = "
    textline ""
    hexmask.long.word 0x0 0xb--0x15 1 "  [21:11]   GACC_SAMP_INCR_TIME            = "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   GACC_SAMP_INCR_ENERGY          = "
  tree.end
  tree "GACC_FREQ_ALT"
   group.long 0x80010--0x80013 "GACC_FREQ_ALT (at 0x90680010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GACC_FIRST_FREQ                = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GACC_FREQ_INCR                 = "
  tree.end
  tree "GACC_CONFIG_ALT"
   group.long 0x80014--0x80017 "GACC_CONFIG_ALT (at 0x90680014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   GACC_ENERGY_MEM_BANK           = " "0 (BANK_0_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_1_IS_CONNECTED_TO_DATA_MOVER),1 (BANK1_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_0_IS_CONNECTED_DATA_MOVER) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   GACC_SAMPLE_MEM_BANK           = " "0 (BANK_0_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_1_IS_CONNECTED_TO_DATA_MOVER),1 (BANK1_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_0_IS_CONNECTED_DATA_MOVER) "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GACC_START                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   GACC_COHERENT_OUT              = " "0 (UPDATE_ENERGY_GRID),1 (OUTPUT_COHERENT_SUMS) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   GACC_FIRST_ENERGY              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   GACC_LAST_NFREQ                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x5--0xf 1 "  [15: 5]   GACC_COHERENT_LEN              = "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   GACC_SUM_TRUNC                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GACC_ENERGY_TRUNC              = " "0,1,2,3 "
  tree.end
  tree "GACC_PEAK_ALT"
   group.long 0x80018--0x8001b "GACC_PEAK_ALT (at 0x90680018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GACC_MAX_INDEX                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GACC_MAX_ENERGY                = "
  tree.end
  tree "GACC_DONE_ALT"
   group.long 0x8001c--0x8001f "GACC_DONE_ALT (at 0x9068001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_DONE_RTC                  = "
  tree.end
  tree "GACC_RTC_ALT"
   group.long 0x80020--0x80023 "GACC_RTC_ALT (at 0x90680020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_CURRENT_RTC               = "
  tree.end
  tree "GACC_SAMPLE_MEM_START_ADDR_ALT"
   group.long 0x81000--0x81003 "GACC_SAMPLE_MEM_START_ADDR_ALT (at 0x90681000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_SAMPLE_MEM                = "
  tree.end
  tree "GACC_SAMPLE_MEM_END_ADDR_ALT"
   group.long 0x819fc--0x819ff "GACC_SAMPLE_MEM_END_ADDR_ALT (at 0x906819fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_SAMPLE_MEM                = "
  tree.end
  tree "GACC_ENERGY_MEM_START_ADDR_ALT"
   group.long 0x82000--0x82003 "GACC_ENERGY_MEM_START_ADDR_ALT (at 0x90682000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_ENERGY_MEM                = "
  tree.end
  tree "GACC_ENERGY_MEM_END_ADDR_ALT"
   group.long 0x829fc--0x829ff "GACC_ENERGY_MEM_END_ADDR_ALT (at 0x906829fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_ENERGY_MEM                = "
  tree.end
  tree "GACC_RTC_WAIT"
   group.long 0x80000--0x80003 "GACC_RTC_WAIT (at 0x90680000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x19 "  [25:24]   GACC_RTC_SELECT                = " "0 (GPS),1 (CDMA),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_RTC_WAIT                  = "
  tree.end
  tree "GACC_START_ADDR"
   group.long 0x80004--0x80007 "GACC_START_ADDR (at 0x90680004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xc--0x17 1 "  [23:12]   GACC_ENERGY_ADDR               = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GACC_SAMPLE_ADDR               = "
  tree.end
  tree "GACC_COUNT"
   group.long 0x80008--0x8000b "GACC_COUNT (at 0x90680008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   GACC_ENERGY_ITER               = "
    textline ""
    hexmask.long.word 0x0 0xf--0x18 1 "  [24:15]   GACC_HYP_ITER                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   GACC_SAMP_ITER                 = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   GACC_FREQ_ITER                 = "
  tree.end
  tree "GACC_INCR"
   group.long 0x8000c--0x8000f "GACC_INCR (at 0x9068000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   GACC_SAMP_INCR_SAMP            = "
    textline ""
    hexmask.long.word 0x0 0xb--0x15 1 "  [21:11]   GACC_SAMP_INCR_TIME            = "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   GACC_SAMP_INCR_ENERGY          = "
  tree.end
  tree "GACC_FREQ"
   group.long 0x80010--0x80013 "GACC_FREQ (at 0x90680010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   GACC_FIRST_FREQ                = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GACC_FREQ_INCR                 = "
  tree.end
  tree "GACC_CONFIG"
   group.long 0x80014--0x80017 "GACC_CONFIG (at 0x90680014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   GACC_ENERGY_MEM_BANK           = " "0 (BANK_0_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_1_IS_CONNECTED_TO_DATA_MOVER),1 (BANK1_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_0_IS_CONNECTED_DATA_MOVER) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   GACC_SAMPLE_MEM_BANK           = " "0 (BANK_0_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_1_IS_CONNECTED_TO_DATA_MOVER),1 (BANK1_IS_CONNECTED_TO_GPS_ACCELERATOR_BANK_0_IS_CONNECTED_DATA_MOVER) "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GACC_START                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   GACC_COHERENT_OUT              = " "0 (UPDATE_ENERGY_GRID),1 (OUTPUT_COHERENT_SUMS) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   GACC_FIRST_ENERGY              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   GACC_LAST_NFREQ                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x5--0xf 1 "  [15: 5]   GACC_COHERENT_LEN              = "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   GACC_SUM_TRUNC                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GACC_ENERGY_TRUNC              = " "0,1,2,3 "
  tree.end
  tree "GACC_PEAK"
   group.long 0x80018--0x8001b "GACC_PEAK (at 0x90680018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GACC_MAX_INDEX                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GACC_MAX_ENERGY                = "
  tree.end
  tree "GACC_DONE"
   group.long 0x8001c--0x8001f "GACC_DONE (at 0x9068001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_DONE_RTC                  = "
  tree.end
  tree "GACC_RTC"
   group.long 0x80020--0x80023 "GACC_RTC (at 0x90680020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GACC_CURRENT_RTC               = "
  tree.end
  tree "GACC_SAMPLE_MEM_START_ADDR"
   group.long 0x81000--0x81003 "GACC_SAMPLE_MEM_START_ADDR (at 0x90681000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_SAMPLE_MEM                = "
  tree.end
  tree "GACC_SAMPLE_MEM_END_ADDR"
   group.long 0x819fc--0x819ff "GACC_SAMPLE_MEM_END_ADDR (at 0x906819fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_SAMPLE_MEM                = "
  tree.end
  tree "GACC_ENERGY_MEM_START_ADDR"
   group.long 0x82000--0x82003 "GACC_ENERGY_MEM_START_ADDR (at 0x90682000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_ENERGY_MEM                = "
  tree.end
  tree "GACC_ENERGY_MEM_END_ADDR"
   group.long 0x829fc--0x829ff "GACC_ENERGY_MEM_END_ADDR (at 0x906829fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GACC_ENERGY_MEM                = "
  tree.end
tree.end
tree "GPIO"
base ad:0x8000a000
tree "GPIO"
  tree "GPIO_OUT_0"
   group.long 0x0--0x3 "GPIO_OUT_0 (at 0x8000a000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xe--0x1e 1 "  [30:14]   GPIO_OUT_30_14                 = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_OUT_12                    = " "0,1 "
  tree.end
  tree "GPIO_OUT_1"
   group.long 0x4--0x7 "GPIO_OUT_1 (at 0x8000a004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   GPIO_OUT_62_55                 = "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GPIO_OUT_53                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x2--0x9 1 "  [ 9: 2]   GPIO_OUT_41_34                 = "
  tree.end
  tree "GPIO_OE_0"
   group.long 0x8--0xb "GPIO_OE_0 (at 0x8000a008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xe--0x1e 1 "  [30:14]   GPIO_OE_30_14                  = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_OE_12                     = " "0,1 "
  tree.end
  tree "GPIO_OE_1"
   group.long 0xc--0xf "GPIO_OE_1 (at 0x8000a00c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   GPIO_OE_62_55                  = "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GPIO_OE_53                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x2--0x9 1 "  [ 9: 2]   GPIO_OE_41_34                  = "
  tree.end
  tree "GPIO_PAGE"
   group.long 0x10--0x13 "GPIO_PAGE (at 0x8000a010)   (shadowed - Use hwio_shadow_ptr->GPIO_PAGE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
  tree "GPIO_CFG"
   group.long 0x14--0x17 "GPIO_CFG (at 0x8000a014)   (shadowed - Use hwio_shadow_ptr->GPIO_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   FUNC_SEL                       = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GPIO_PULL                      = " "0 (NO_PULL),1 (PULL_DOWN),2 (KEEPER),3 (PULL_UP) "
  tree.end
  tree "GPIO_IN_0"
   group.long 0x18--0x1b "GPIO_IN_0 (at 0x8000a018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xe--0x1e 1 "  [30:14]   GPIO_IN_30_14                  = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_IN_12                     = " "0,1 "
  tree.end
  tree "GPIO_IN_1"
   group.long 0x1c--0x1f "GPIO_IN_1 (at 0x8000a01c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x17--0x1e 1 "  [30:23]   GPIO_IN_62_55                  = "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GPIO_IN_53                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x2--0x9 1 "  [ 9: 2]   GPIO_IN_41_34                  = "
  tree.end
tree.end

base ad:0x84022000
tree "GPIO2"
  tree "GPIO2_OE_0"
   group.long 0x0--0x3 "GPIO2_OE_0 (at 0x84022000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GPIO_OE_31                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   GPIO_OE_13                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_OE_11_0                   = "
  tree.end
  tree "GPIO2_OE_1"
   group.long 0x4--0x7 "GPIO2_OE_1 (at 0x84022004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   GPIO_OE_54                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xa--0x14 1 "  [20:10]   GPIO_OE_52_42                  = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GPIO_OE_33_32                  = " "0,1,2,3 "
  tree.end
  tree "GPIO2_OUT_0"
   group.long 0x8--0xb "GPIO2_OUT_0 (at 0x84022008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GPIO_OUT_31                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   GPIO_OUT_13                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_OUT_11_0                  = "
  tree.end
  tree "GPIO2_OUT_1"
   group.long 0xc--0xf "GPIO2_OUT_1 (at 0x8402200c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   GPIO_OUT_54                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xa--0x14 1 "  [20:10]   GPIO_OUT_52_42                 = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GPIO_OUT_33_32                 = " "0,1,2,3 "
  tree.end
  tree "GPIO2_PAGE"
   group.long 0x10--0x13 "GPIO2_PAGE (at 0x84022010)   (shadowed - Use hwio_shadow_ptr->GPIO2_PAGE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
  tree "GPIO2_CFG"
   group.long 0x14--0x17 "GPIO2_CFG (at 0x84022014)   (shadowed - Use hwio_shadow_ptr->GPIO2_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   FUNC_SEL                       = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GPIO_PULL                      = " "0 (NO_PULL),1 (PULL_DOWN),2 (KEEPER),3 (PULL_UP) "
  tree.end
  tree "GPIO2_IN_0"
   group.long 0x18--0x1b "GPIO2_IN_0 (at 0x84022018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GPIO_IN_31                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   GPIO_IN_13                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_IN_11_0                   = "
  tree.end
  tree "GPIO2_IN_1"
   group.long 0x1c--0x1f "GPIO2_IN_1 (at 0x8402201c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   GPIO_IN_54                     = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xa--0x14 1 "  [20:10]   GPIO_IN_52_42                  = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GPIO_IN_33_32                  = " "0,1,2,3 "
  tree.end
tree.end
tree.end

base ad:0x90500000
tree "GPS_SRCH"
  tree "GPS_SRCH_DM_BYPASS"
   group.long 0x0--0x3 "GPS_SRCH_DM_BYPASS (at 0x90500000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SRCH_DM_BYPASS                 = " "0,1 "
  tree.end
  tree "GPS_SRCH_RESET"
   group.long 0x4--0x7 "GPS_SRCH_RESET (at 0x90500004)   (shadowed - Use hwio_shadow_ptr->GPS_SRCH_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SRCH_RESET                     = " "0,1 "
  tree.end
  tree "GPS_SRCH_CTL"
   group.long 0x8--0xb "GPS_SRCH_CTL (at 0x90500008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SRCH_SW_DP_CLK_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SRCH_TESTBUS_OUT_SEL           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SRCH_TESTBUS_IN_SEL            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SRCH_SIGNAL_LOG                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SRCH_SW_CLK_HALT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SRCH_PN_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SRCH_DP_CLK_EN_SEL             = " "0,1 "
  tree.end
  tree "GPS_SRCH_TESTBUS_OUT"
   group.long 0xc--0xf "GPS_SRCH_TESTBUS_OUT (at 0x9050000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SRCH_AHB2AHB_IDLE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   SRCH_OUT_FIFO_ERR              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   SRCH_SIGLOG_ERR                = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0xc--0x13 1 "  [19:12]   OUT_FIFO_AVAIL                 = "
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   CMD_FIFO_AVAIL                 = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   SRCH_FSM                       = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SRCH_SW_CLK_IS_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SRCH_CLK_IS_OFF                = " "0,1 "
  tree.end
  tree "GPS_SRCH_SS_TESTBUS_OUT"
   group.long 0x10--0x13 "GPS_SRCH_SS_TESTBUS_OUT (at 0x90500010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SRCH_SS_STOP                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SRCH_SS_ANT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SRCH_SS_REQ                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SRCH_SS_ADDR                   = "
  tree.end
  tree "ALT_GPS_SRCH_CMD"
   group.long 0x80000--0x80003 "ALT_GPS_SRCH_CMD (at 0x90580000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_CMD                       = "
  tree.end
  tree "ALT_GPS_SRCH_OUT"
   group.long 0xc0000--0xc0003 "ALT_GPS_SRCH_OUT (at 0x905c0000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_OUT                       = "
  tree.end
  tree "GPS_SRCH_CMD_START_ADDR"
   group.long 0x80000--0x80003 "GPS_SRCH_CMD_START_ADDR (at 0x90580000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_CMD                       = "
  tree.end
  tree "GPS_SRCH_CMD_END_ADDR"
   group.long 0xbfffc--0xbffff "GPS_SRCH_CMD_END_ADDR (at 0x905bfffc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_CMD                       = "
  tree.end
  tree "GPS_SRCH_OUT_START_ADDR"
   group.long 0xc0000--0xc0003 "GPS_SRCH_OUT_START_ADDR (at 0x905c0000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_OUT                       = "
  tree.end
  tree "GPS_SRCH_OUT_END_ADDR"
   group.long 0xffffc--0xfffff "GPS_SRCH_OUT_END_ADDR (at 0x905ffffc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SRCH_OUT                       = "
  tree.end
  tree "GPS_SRCH_CMD_ST0"
   group.long 0x80004--0x80007 "GPS_SRCH_CMD_ST0 (at 0x90580004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   SRCH_CMD_ID                    = "
    textline ""
    bitfld.long 0x0 0x1a--0x1b "  [27:26]   SRCH_RTC_SELECT                = " "0 (GPS),1 (CDMA),2 (reserved),3 (reserved) "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   SRCH_WAIT_RTC                  = "
  tree.end
  tree "GPS_SRCH_CMD_DIAG0"
   group.long 0x80008--0x8000b "GPS_SRCH_CMD_DIAG0 (at 0x90580008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   SRCH_CMD_ID                    = "
    textline ""
    bitfld.long 0x0 0x1a--0x1b "  [27:26]   SRCH_RTC_SELECT                = " "0 (GPS),1 (CDMA),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SRCH_RTC_WR_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   SRCH_DONE_WR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SRCH_STALL_CNT_WR_EN           = " "0,1 "
  tree.end
  tree "GPS_SRCH_CMD_WD0"
   group.long 0x8000c--0x8000f "GPS_SRCH_CMD_WD0 (at 0x9058000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   SRCH_CMD_ID                    = "
    textline ""
    bitfld.long 0x0 0x1b "  [   27]   SRCH_ANTENNA                   = " "0 (ANTENNA0),1 (ANTENNA1) "
    textline ""
    hexmask.long.byte 0x0 0x16--0x1a 1 "  [26:22]   SRCH_NUM_HYP                   = "
    textline ""
    bitfld.long 0x0 0x13--0x15 "  [21:19]   SRCH_OUTPUT_TRUNC              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   SRCH_ROTATOR_START_PHASE       = "
  tree.end
  tree "GPS_SRCH_CMD_WD1"
   group.long 0x80010--0x80013 "GPS_SRCH_CMD_WD1 (at 0x90580010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   SRCH_X1X2_MODE                 = " "0 (X2),1 (X1) "
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   SRCH_PN_Q_STATE                = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SRCH_GPS_DATA_BIT              = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   SRCH_PN_I_STATE                = "
  tree.end
  tree "GPS_SRCH_CMD_WD2"
   group.long 0x80014--0x80017 "GPS_SRCH_CMD_WD2 (at 0x90580014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1e 1 "  [30:12]   SRCH_ROTATOR_FREQ              = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SRCH_SERVER_ADDR               = "
  tree.end
  tree "GPS_SRCH_CMD_CDMA_WD3"
   group.long 0x80018--0x8001b "GPS_SRCH_CMD_CDMA_WD3 (at 0x90580018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1f 1 "  [31:20]   SRCH_INTEG_LENG                = "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   SRCH_QOF_SEL                   = " "0,1,2,3 "
    textline ""
    hexmask.long.word 0x0 0x9--0x11 1 "  [17: 9]   SRCH_WALSH_FUNC                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   SRCH_PN_OFFSET                 = "
  tree.end
  tree "GPS_SRCH_CMD_GPS_WD3"
   group.long 0x8001c--0x8001f "GPS_SRCH_CMD_GPS_WD3 (at 0x9058001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1f 1 "  [31:20]   SRCH_INTEG_LENG                = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SRCH_GPS_INTERP_OFFSET         = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "GPS_SRCH_CMD_HDR_WD3"
   group.long 0x80020--0x80023 "GPS_SRCH_CMD_HDR_WD3 (at 0x90580020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x14--0x1f 1 "  [31:20]   SRCH_INTEG_LENG                = "
  tree.end
tree.end
tree "GSBI"
base ad:0x98000000
tree "GSBI0_GSBI0_CTRL"
  tree "GSBI0_GSBI_CTRL_REG"
   group.long 0x0--0x3 "GSBI0_GSBI_CTRL_REG (at 0x98000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DEBUG                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   PROTOCOL_CODE                  = " "0 (IDLE),1 (AUDIO),2 (I2CC),3 (SPI),4 (UART),5 (R_UIM),6 (UARTZ),7 (COMBINER_COUNTER_7) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CLOCK_ENABLE3                  = " "0 (DISABLE_SPI_CLOCK),1 (ENABLE_SPI_CLOCK) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CLOCK_ENABLE2                  = " "0 (DISABLE_I2CC_CLOCK),1 (ENABLE_I2CC_CLOCK) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CLOCK_ENABLE1                  = " "0 (DISABLE_UART_DM_CLOCK),1 (ENABLE_UART_DM_CLOCK) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SPI_CHIP_SELECTS               = " "0 (DISABLE_EXTRA_SPI_CHIP_SELECTS),1 (ENABLE_EXTRA_SPI_CHIP_SELECTS) "
  tree.end
  tree "GSBI0_GSBI_DBG0_REG"
   group.long 0x4--0x7 "GSBI0_GSBI_DBG0_REG (at 0x98000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY0                     = " "0,1,2,3 "
  tree.end
  tree "GSBI0_GSBI_DBG1_REG"
   group.long 0x8--0xb "GSBI0_GSBI_DBG1_REG (at 0x98000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY1                     = " "0,1,2,3 "
  tree.end
  tree "GSBI0_GSBI_DBG2_REG"
   group.long 0xc--0xf "GSBI0_GSBI_DBG2_REG (at 0x9800000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY2                     = " "0,1,2,3 "
  tree.end
  tree "GSBI0_GSBI_DBG3_REG"
   group.long 0x10--0x13 "GSBI0_GSBI_DBG3_REG (at 0x98000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI                           = " "0,1,2,3 "
  tree.end
tree.end

base ad:0x9c000000
tree "GSBI0_GSBI0_I2C"
  tree "GSBI0_I2C_WRITE_DATA"
   group.long 0x0--0x3 "GSBI0_I2C_WRITE_DATA (at 0x9c000000)   (shadowed - Use hwio_shadow_ptr->GSBI0_I2C_WRITE_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   LAST_BYTE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ADDR_BYTE                      = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI0_I2C_CLK_CTL"
   group.long 0x4--0x7 "GSBI0_I2C_CLK_CTL (at 0x9c000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HS_DIVIDER_VALUE               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FS_DIVIDER_VALUE               = "
  tree.end
  tree "GSBI0_I2C_STATUS"
   group.long 0x8--0xb "GSBI0_I2C_STATUS (at 0x9c000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   CLK_STATE                      = " "0 (RESET_BUSIDLE_STATE),1 (NOT_MASTER_STATE),2 (HIGH_STATE),3 (LOW_STATE),4 (HIGH_WAIT_STATE),5 (FORCED_LOW_STATE),6 (HS_ADDR_LOW_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0xa--0xc "  [12:10]   DATA_STATE                     = " "0 (RESET_WAIT_STATE),1 (TX_ADDR_STATE),2 (TX_DATA_STATE),3 (TX_HS_ADDR_STATE),4 (TX_10_BIT_ADDR_STATE),5 (TX_2ND_BYTE_STATE),6 (RX_DATA_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BUS_MASTER                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BUS_ACTIVE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FAILED                         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INVALID_WRITE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ARB_LOST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PACKET_NACKED                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BUS_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RD_BUFFER_FULL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WR_BUFFER_FULL                 = " "0,1 "
  tree.end
  tree "GSBI0_I2C_READ_DATA"
   group.long 0xc--0xf "GSBI0_I2C_READ_DATA (at 0x9c00000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI0_I2C_INTERFACE_SELECT"
   group.long 0x10--0x13 "GSBI0_I2C_INTERFACE_SELECT (at 0x9c000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SDA                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SCL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TEST_DATA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTF_SELECT                    = " "0,1 "
  tree.end
tree.end

base ad:0x9e000000
tree "GSBI0_GSBI0_SPI"
  tree "GSBI0_SPI_CONFIG"
   group.long 0x0--0x3 "GSBI0_SPI_CONFIG (at 0x9e000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_FIRST                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LOOP_BACK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   NO_INPUT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   NO_OUTPUT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SLAVE_OPERATION                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   N                              = "
  tree.end
  tree "GSBI0_SPI_IO_CONTROL"
   group.long 0x4--0x7 "GSBI0_SPI_IO_CONTROL (at 0x9e000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CLK_IDLE_HIGH                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CLK_ALWAYS_ON                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MX_CS_MODE                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CS_N_POLARITY                  = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TRISTATE_CS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   NO_TRI_STATE                   = " "0,1 "
  tree.end
  tree "GSBI0_SPI_IO_MODES"
   group.long 0x8--0xb "GSBI0_SPI_IO_MODES (at 0x9e000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   OUTPUT_BIT_SHIFT_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PACK_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   UNPACK_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   INPUT_MODE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   OUTPUT_MODE                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   INPUT_FIFO_SIZE                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   INPUT_BLOCK_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OUTPUT_FIFO_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_BLOCK_SIZE              = " "0,1,2,3 "
  tree.end
  tree "GSBI0_SPI_SW_RESET"
   group.long 0xc--0xf "GSBI0_SPI_SW_RESET (at 0x9e00000c)   (shadowed - Use hwio_shadow_ptr->GSBI0_SPI_SW_RESET to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "GSBI0_SPI_TIME_OUT"
   group.long 0x10--0x13 "GSBI0_SPI_TIME_OUT (at 0x9e000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_VALUE                 = "
  tree.end
  tree "GSBI0_SPI_TIME_OUT_CURRENT"
   group.long 0x14--0x17 "GSBI0_SPI_TIME_OUT_CURRENT (at 0x9e000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_CURRENT               = "
  tree.end
  tree "GSBI0_SPI_MX_OUTPUT_COUNT"
   group.long 0x18--0x1b "GSBI0_SPI_MX_OUTPUT_COUNT (at 0x9e000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_COUNT                = "
  tree.end
  tree "GSBI0_SPI_MX_OUTPUT_CNT_CURRENT"
   group.long 0x1c--0x1f "GSBI0_SPI_MX_OUTPUT_CNT_CURRENT (at 0x9e00001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_CNT_CURRENT          = "
  tree.end
  tree "GSBI0_SPI_MX_INPUT_COUNT"
   group.long 0x20--0x23 "GSBI0_SPI_MX_INPUT_COUNT (at 0x9e000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_COUNT                 = "
  tree.end
  tree "GSBI0_SPI_MX_INPUT_CNT_CURRENT"
   group.long 0x24--0x27 "GSBI0_SPI_MX_INPUT_CNT_CURRENT (at 0x9e000024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_CNT_CURRENT           = "
  tree.end
  tree "GSBI0_SPI_MX_READ_COUNT"
   group.long 0x28--0x2b "GSBI0_SPI_MX_READ_COUNT (at 0x9e000028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_COUNT                  = "
  tree.end
  tree "GSBI0_SPI_MX_READ_CNT_CURRENT"
   group.long 0x2c--0x2f "GSBI0_SPI_MX_READ_CNT_CURRENT (at 0x9e00002c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_CNT_CURRENT            = "
  tree.end
  tree "GSBI0_SPI_OPERATIONAL"
   group.long 0x30--0x33 "GSBI0_SPI_OPERATIONAL (at 0x9e000030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MAX_INPUT_DONE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MAX_OUTPUT_DONE_FLAG           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_SERVICE_FLAG             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   OUTPUT_SERVICE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_FIFO_FULL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   OUTPUT_FIFO_FULL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_FIFO_NOT_EMPTY           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   OUTPUT_FIFO_NOT_EMPTY          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   STATE_VALID                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STATE                          = " "0,1,2,3 "
  tree.end
  tree "GSBI0_SPI_ERROR_FLAGS"
   group.long 0x34--0x37 "GSBI0_SPI_ERROR_FLAGS (at 0x9e000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR              = " "0,1 "
  tree.end
  tree "GSBI0_SPI_ERROR_FLAGS_EN"
   group.long 0x38--0x3b "GSBI0_SPI_ERROR_FLAGS_EN (at 0x9e000038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR_EN           = " "0,1 "
  tree.end
  tree "GSBI0_SPI_DEASSERT_WAIT"
   group.long 0x3c--0x3f "GSBI0_SPI_DEASSERT_WAIT (at 0x9e00003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DEASSERT_WAIT                  = "
  tree.end
  tree "GSBI0_SPI_OUTPUT_DEBUG"
   group.long 0x40--0x43 "GSBI0_SPI_OUTPUT_DEBUG (at 0x9e000040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT_DEBUG_DATA              = "
  tree.end
  tree "GSBI0_SPI_INPUT_DEBUG"
   group.long 0x44--0x47 "GSBI0_SPI_INPUT_DEBUG (at 0x9e000044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT_DEBUG_DATA               = "
  tree.end
  tree "GSBI0_SPI_FIFO_WORD_CNT"
   group.long 0x48--0x4b "GSBI0_SPI_FIFO_WORD_CNT (at 0x9e000048)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INPUT_FIFO_WORD_CNT            = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   OUTPUT_FIFO_WORD_CNT           = "
  tree.end
  tree "GSBI0_SPI_TEST_CTRL"
   group.long 0x4c--0x4f "GSBI0_SPI_TEST_CTRL (at 0x9e00004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SPI_TEST_BUS_EN                = " "0,1 "
  tree.end
  tree "GSBI0_SPI_OUTPUT_FIFO"
   group.long 0x100--0x103 "GSBI0_SPI_OUTPUT_FIFO (at 0x9e000100)   (shadowed - Use hwio_shadow_ptr->GSBI0_SPI_OUTPUT_FIFO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT                         = "
  tree.end
  tree "GSBI0_SPI_INPUT_FIFO"
   group.long 0x200--0x203 "GSBI0_SPI_INPUT_FIFO (at 0x9e000200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT                          = "
  tree.end
tree.end

base ad:0x9a000000
tree "GSBI0_GSBI0_UART"
  tree "GSBI0_UART_DM_MR1"
   group.long 0x0--0x3 "GSBI0_UART_DM_MR1 (at 0x9a000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x8--0x1f 1 "  [31: 8]   AUTO_RFR_LEVEL1                = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RX_RDY_CTL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CTS_CTL                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   AUTO_RFR_LEVEL0                = "
  tree.end
  tree "GSBI0_UART_DM_MR2"
   group.long 0x4--0x7 "GSBI0_UART_DM_MR2 (at 0x9a000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LOOPBACK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_MODE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BITS_PER_CHAR                  = " "0 (5_BITS),1 (6_BITS),2 (7_BITS),3 (8_BITS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   STOP_BIT_LEN                   = " "0 (0_563),1 (1_000_BIT_TIME),2 (1_563),3 (2_000_BIT_TIMES) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PARITY_MODE                    = " "0 (NO_PARITY),1 (ODD_PARITY),2 (EVEN_PARITY),3 (SPACE_PARITY) "
  tree.end
  tree "GSBI0_UART_DM_CSR"
   group.long 0x8--0xb "GSBI0_UART_DM_CSR (at 0x9a000008)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_CSR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UART_RX_CLK_SEL                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   UART_TX_CLK_SEL                = "
  tree.end
  tree "GSBI0_UART_DM_TF"
   group.long 0x70--0x73 "GSBI0_UART_DM_TF (at 0x9a000070)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_TF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI0_UART_DM_TF_2"
   group.long 0x74--0x77 "GSBI0_UART_DM_TF_2 (at 0x9a000074)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_TF_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI0_UART_DM_TF_3"
   group.long 0x78--0x7b "GSBI0_UART_DM_TF_3 (at 0x9a000078)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_TF_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI0_UART_DM_TF_4"
   group.long 0x7c--0x7f "GSBI0_UART_DM_TF_4 (at 0x9a00007c)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_TF_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI0_UART_DM_CR"
   group.long 0x10--0x13 "GSBI0_UART_DM_CR (at 0x9a000010)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_CR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CHANNEL_COMMAND_MSB            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GENERAL_COMMAND                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHANNEL_COMMAND_LSB            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UART_TX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UART_TX_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UART_RX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UART_RX_EN                     = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_IMR"
   group.long 0x14--0x17 "GSBI0_UART_DM_IMR (at 0x9a000014)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_IMR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_IPR"
   group.long 0x18--0x1b "GSBI0_UART_DM_IPR (at 0x9a000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   STALE_TIMEOUT_MSB              = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_DATA                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STALE_TIMEOUT_LSB              = "
  tree.end
  tree "GSBI0_UART_DM_TFWR"
   group.long 0x1c--0x1f "GSBI0_UART_DM_TFWR (at 0x9a00001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TFW                            = "
  tree.end
  tree "GSBI0_UART_DM_RFWR"
   group.long 0x20--0x23 "GSBI0_UART_DM_RFWR (at 0x9a000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RFW                            = "
  tree.end
  tree "GSBI0_UART_DM_HCR"
   group.long 0x24--0x27 "GSBI0_UART_DM_HCR (at 0x9a000024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "GSBI0_UART_DM_DMRX"
   group.long 0x34--0x37 "GSBI0_UART_DM_DMRX (at 0x9a000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   RX_DM_CRCI_CHARS               = "
  tree.end
  tree "GSBI0_UART_DM_IRDA"
   group.long 0x38--0x3b "GSBI0_UART_DM_IRDA (at 0x9a000038)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_IRDA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MEDIUM_RATE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   IRDA_LOOPBACK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_IRDA_TX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INVERT_IRDA_RX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRDA_EN                        = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_DMEN"
   group.long 0x3c--0x3f "GSBI0_UART_DM_DMEN (at 0x9a00003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX_DM_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DM_EN                       = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_NO_CHARS_FOR_TX"
   group.long 0x40--0x43 "GSBI0_UART_DM_NO_CHARS_FOR_TX (at 0x9a000040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   TX_TOTAL_TRANS_LEN             = "
  tree.end
  tree "GSBI0_UART_DM_BADR"
   group.long 0x44--0x47 "GSBI0_UART_DM_BADR (at 0x9a000044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RX_BASE_ADDR                   = "
  tree.end
  tree "GSBI0_UART_DM_TESTSL"
   group.long 0x48--0x4b "GSBI0_UART_DM_TESTSL (at 0x9a000048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_EN                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_SEL                       = "
  tree.end
  tree "GSBI0_UART_DM_MISR_MODE"
   group.long 0x60--0x63 "GSBI0_UART_DM_MISR_MODE (at 0x9a000060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                           = " "0 (DISABLED),1 (ENABLED_TX_TEST),2 (ENABLED_RX_TEST),3 (reserved) "
  tree.end
  tree "GSBI0_UART_DM_MISR_RESET"
   group.long 0x64--0x67 "GSBI0_UART_DM_MISR_RESET (at 0x9a000064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_MISR_EXPORT"
   group.long 0x68--0x6b "GSBI0_UART_DM_MISR_EXPORT (at 0x9a000068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXPORT                         = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_MISR_VAL"
   group.long 0x6c--0x6f "GSBI0_UART_DM_MISR_VAL (at 0x9a00006c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   VAL                            = "
  tree.end
  tree "GSBI0_UART_DM_SIM_CFG"
   group.long 0x80--0x83 "GSBI0_UART_DM_SIM_CFG (at 0x9a000080)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_SIM_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   UIM_TX_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   UIM_RX_MODE                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SIM_STOP_BIT_LEN               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SIM_CLK_ON                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SIM_CLK_TD8_SEL                = " "0 (TD4),1 (TD8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SIM_CLK_STOP_HIGH              = " "0 (LOW),1 (HIGH) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SIM_CLK_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_RX                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SWAP_D                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INV_D                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SIM_SEL                        = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_TEST_WR_ADDR"
   group.long 0x84--0x87 "GSBI0_UART_DM_TEST_WR_ADDR (at 0x9a000084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_ADDR                   = "
  tree.end
  tree "GSBI0_UART_DM_TEST_WR_DATA"
   group.long 0x88--0x8b "GSBI0_UART_DM_TEST_WR_DATA (at 0x9a000088)   (shadowed - Use hwio_shadow_ptr->GSBI0_UART_DM_TEST_WR_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_DATA                   = "
  tree.end
  tree "GSBI0_UART_DM_TEST_RD_ADDR"
   group.long 0x8c--0x8f "GSBI0_UART_DM_TEST_RD_ADDR (at 0x9a00008c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_ADDR                   = "
  tree.end
  tree "GSBI0_UART_DM_SR"
   group.long 0x8--0xb "GSBI0_UART_DM_SR (at 0x9a000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   HUNT_CHAR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RX_BREAK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PAR_FRAME_ERR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UART_OVERRUN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TXEMT                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TXRDY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXFULL                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RXRDY                          = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_RF"
   group.long 0x70--0x73 "GSBI0_UART_DM_RF (at 0x9a000070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI0_UART_DM_RF_2"
   group.long 0x74--0x77 "GSBI0_UART_DM_RF_2 (at 0x9a000074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI0_UART_DM_RF_3"
   group.long 0x78--0x7b "GSBI0_UART_DM_RF_3 (at 0x9a000078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI0_UART_DM_RF_4"
   group.long 0x7c--0x7f "GSBI0_UART_DM_RF_4 (at 0x9a00007c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI0_UART_DM_MISR"
   group.long 0x10--0x13 "GSBI0_UART_DM_MISR (at 0x9a000010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   UART_MISR                      = "
  tree.end
  tree "GSBI0_UART_DM_ISR"
   group.long 0x14--0x17 "GSBI0_UART_DM_ISR (at 0x9a000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI0_UART_DM_RX_TOTAL_SNAP"
   group.long 0x38--0x3b "GSBI0_UART_DM_RX_TOTAL_SNAP (at 0x9a000038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RX_TOTAL_BYTES                 = "
  tree.end
  tree "GSBI0_UART_DM_TXFS"
   group.long 0x4c--0x4f "GSBI0_UART_DM_TXFS (at 0x9a00004c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   TX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   TX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI0_UART_DM_RXFS"
   group.long 0x50--0x53 "GSBI0_UART_DM_RXFS (at 0x9a000050)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   RX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI0_UART_DM_TEST_RD_DATA"
   group.long 0x90--0x93 "GSBI0_UART_DM_TEST_RD_DATA (at 0x9a000090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_DATA                   = "
  tree.end
tree.end

base ad:0xa0000000
tree "GSBI1_GSBI1_CTRL"
  tree "GSBI1_GSBI_CTRL_REG"
   group.long 0x0--0x3 "GSBI1_GSBI_CTRL_REG (at 0xa0000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DEBUG                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   PROTOCOL_CODE                  = " "0 (IDLE),1 (AUDIO),2 (I2CC),3 (SPI),4 (UART),5 (R_UIM),6 (UARTZ),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CLOCK_ENABLE3                  = " "0 (DISABLE_SPI_CLOCK),1 (ENABLE_SPI_CLOCK) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CLOCK_ENABLE2                  = " "0 (DISABLE_I2CC_CLOCK),1 (ENABLE_I2CC_CLOCK) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CLOCK_ENABLE1                  = " "0 (DISABLE_UART_DM_CLOCK),1 (ENABLE_UART_DM_CLOCK) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SPI_CHIP_SELECTS               = " "0 (DISABLE_EXTRA_SPI_CHIP_SELECTS),1 (ENABLE_EXTRA_SPI_CHIP_SELECTS) "
  tree.end
  tree "GSBI1_GSBI_DBG0_REG"
   group.long 0x4--0x7 "GSBI1_GSBI_DBG0_REG (at 0xa0000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY0                     = " "0,1,2,3 "
  tree.end
  tree "GSBI1_GSBI_DBG1_REG"
   group.long 0x8--0xb "GSBI1_GSBI_DBG1_REG (at 0xa0000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY1                     = " "0,1,2,3 "
  tree.end
  tree "GSBI1_GSBI_DBG2_REG"
   group.long 0xc--0xf "GSBI1_GSBI_DBG2_REG (at 0xa000000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY2                     = " "0,1,2,3 "
  tree.end
  tree "GSBI1_GSBI_DBG3_REG"
   group.long 0x10--0x13 "GSBI1_GSBI_DBG3_REG (at 0xa0000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI                           = " "0,1,2,3 "
  tree.end
tree.end

base ad:0xa4000000
tree "GSBI1_GSBI1_I2C"
  tree "GSBI1_I2C_WRITE_DATA"
   group.long 0x0--0x3 "GSBI1_I2C_WRITE_DATA (at 0xa4000000)   (shadowed - Use hwio_shadow_ptr->GSBI1_I2C_WRITE_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   LAST_BYTE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ADDR_BYTE                      = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI1_I2C_CLK_CTL"
   group.long 0x4--0x7 "GSBI1_I2C_CLK_CTL (at 0xa4000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HS_DIVIDER_VALUE               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FS_DIVIDER_VALUE               = "
  tree.end
  tree "GSBI1_I2C_STATUS"
   group.long 0x8--0xb "GSBI1_I2C_STATUS (at 0xa4000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   CLK_STATE                      = " "0 (RESET_BUSIDLE_STATE),1 (NOT_MASTER_STATE),2 (HIGH_STATE),3 (LOW_STATE),4 (HIGH_WAIT_STATE),5 (FORCED_LOW_STATE),6 (HS_ADDR_LOW_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0xa--0xc "  [12:10]   DATA_STATE                     = " "0 (RESET_WAIT_STATE),1 (TX_ADDR_STATE),2 (TX_DATA_STATE),3 (TX_HS_ADDR_STATE),4 (TX_10_BIT_ADDR_STATE),5 (TX_2ND_BYTE_STATE),6 (RX_DATA_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BUS_MASTER                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BUS_ACTIVE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FAILED                         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INVALID_WRITE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ARB_LOST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PACKET_NACKED                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BUS_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RD_BUFFER_FULL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WR_BUFFER_FULL                 = " "0,1 "
  tree.end
  tree "GSBI1_I2C_READ_DATA"
   group.long 0xc--0xf "GSBI1_I2C_READ_DATA (at 0xa400000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI1_I2C_INTERFACE_SELECT"
   group.long 0x10--0x13 "GSBI1_I2C_INTERFACE_SELECT (at 0xa4000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SDA                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SCL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TEST_DATA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTF_SELECT                    = " "0,1 "
  tree.end
tree.end

base ad:0xa6000000
tree "GSBI1_GSBI1_SPI"
  tree "GSBI1_SPI_CONFIG"
   group.long 0x0--0x3 "GSBI1_SPI_CONFIG (at 0xa6000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_FIRST                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LOOP_BACK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   NO_INPUT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   NO_OUTPUT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SLAVE_OPERATION                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   N                              = "
  tree.end
  tree "GSBI1_SPI_IO_CONTROL"
   group.long 0x4--0x7 "GSBI1_SPI_IO_CONTROL (at 0xa6000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CLK_IDLE_HIGH                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CLK_ALWAYS_ON                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MX_CS_MODE                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CS_N_POLARITY                  = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TRISTATE_CS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   NO_TRI_STATE                   = " "0,1 "
  tree.end
  tree "GSBI1_SPI_IO_MODES"
   group.long 0x8--0xb "GSBI1_SPI_IO_MODES (at 0xa6000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   OUTPUT_BIT_SHIFT_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PACK_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   UNPACK_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   INPUT_MODE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   OUTPUT_MODE                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   INPUT_FIFO_SIZE                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   INPUT_BLOCK_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OUTPUT_FIFO_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_BLOCK_SIZE              = " "0,1,2,3 "
  tree.end
  tree "GSBI1_SPI_SW_RESET"
   group.long 0xc--0xf "GSBI1_SPI_SW_RESET (at 0xa600000c)   (shadowed - Use hwio_shadow_ptr->GSBI1_SPI_SW_RESET to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "GSBI1_SPI_TIME_OUT"
   group.long 0x10--0x13 "GSBI1_SPI_TIME_OUT (at 0xa6000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_VALUE                 = "
  tree.end
  tree "GSBI1_SPI_TIME_OUT_CURRENT"
   group.long 0x14--0x17 "GSBI1_SPI_TIME_OUT_CURRENT (at 0xa6000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_CURRENT               = "
  tree.end
  tree "GSBI1_SPI_MX_OUTPUT_COUNT"
   group.long 0x18--0x1b "GSBI1_SPI_MX_OUTPUT_COUNT (at 0xa6000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_COUNT                = "
  tree.end
  tree "GSBI1_SPI_MX_OUTPUT_CNT_CURRENT"
   group.long 0x1c--0x1f "GSBI1_SPI_MX_OUTPUT_CNT_CURRENT (at 0xa600001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_CNT_CURRENT          = "
  tree.end
  tree "GSBI1_SPI_MX_INPUT_COUNT"
   group.long 0x20--0x23 "GSBI1_SPI_MX_INPUT_COUNT (at 0xa6000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_COUNT                 = "
  tree.end
  tree "GSBI1_SPI_MX_INPUT_CNT_CURRENT"
   group.long 0x24--0x27 "GSBI1_SPI_MX_INPUT_CNT_CURRENT (at 0xa6000024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_CNT_CURRENT           = "
  tree.end
  tree "GSBI1_SPI_MX_READ_COUNT"
   group.long 0x28--0x2b "GSBI1_SPI_MX_READ_COUNT (at 0xa6000028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_COUNT                  = "
  tree.end
  tree "GSBI1_SPI_MX_READ_CNT_CURRENT"
   group.long 0x2c--0x2f "GSBI1_SPI_MX_READ_CNT_CURRENT (at 0xa600002c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_CNT_CURRENT            = "
  tree.end
  tree "GSBI1_SPI_OPERATIONAL"
   group.long 0x30--0x33 "GSBI1_SPI_OPERATIONAL (at 0xa6000030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MAX_INPUT_DONE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MAX_OUTPUT_DONE_FLAG           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_SERVICE_FLAG             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   OUTPUT_SERVICE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_FIFO_FULL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   OUTPUT_FIFO_FULL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_FIFO_NOT_EMPTY           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   OUTPUT_FIFO_NOT_EMPTY          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   STATE_VALID                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STATE                          = " "0,1,2,3 "
  tree.end
  tree "GSBI1_SPI_ERROR_FLAGS"
   group.long 0x34--0x37 "GSBI1_SPI_ERROR_FLAGS (at 0xa6000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR              = " "0,1 "
  tree.end
  tree "GSBI1_SPI_ERROR_FLAGS_EN"
   group.long 0x38--0x3b "GSBI1_SPI_ERROR_FLAGS_EN (at 0xa6000038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR_EN           = " "0,1 "
  tree.end
  tree "GSBI1_SPI_DEASSERT_WAIT"
   group.long 0x3c--0x3f "GSBI1_SPI_DEASSERT_WAIT (at 0xa600003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DEASSERT_WAIT                  = "
  tree.end
  tree "GSBI1_SPI_OUTPUT_DEBUG"
   group.long 0x40--0x43 "GSBI1_SPI_OUTPUT_DEBUG (at 0xa6000040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT_DEBUG_DATA              = "
  tree.end
  tree "GSBI1_SPI_INPUT_DEBUG"
   group.long 0x44--0x47 "GSBI1_SPI_INPUT_DEBUG (at 0xa6000044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT_DEBUG_DATA               = "
  tree.end
  tree "GSBI1_SPI_FIFO_WORD_CNT"
   group.long 0x48--0x4b "GSBI1_SPI_FIFO_WORD_CNT (at 0xa6000048)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INPUT_FIFO_WORD_CNT            = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   OUTPUT_FIFO_WORD_CNT           = "
  tree.end
  tree "GSBI1_SPI_TEST_CTRL"
   group.long 0x4c--0x4f "GSBI1_SPI_TEST_CTRL (at 0xa600004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SPI_TEST_BUS_EN                = " "0,1 "
  tree.end
  tree "GSBI1_SPI_OUTPUT_FIFO"
   group.long 0x100--0x103 "GSBI1_SPI_OUTPUT_FIFO (at 0xa6000100)   (shadowed - Use hwio_shadow_ptr->GSBI1_SPI_OUTPUT_FIFO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT                         = "
  tree.end
  tree "GSBI1_SPI_INPUT_FIFO"
   group.long 0x200--0x203 "GSBI1_SPI_INPUT_FIFO (at 0xa6000200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT                          = "
  tree.end
tree.end

base ad:0xa2000000
tree "GSBI1_GSBI1_UART"
  tree "GSBI1_UART_DM_MR1"
   group.long 0x0--0x3 "GSBI1_UART_DM_MR1 (at 0xa2000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x8--0x1f 1 "  [31: 8]   AUTO_RFR_LEVEL1                = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RX_RDY_CTL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CTS_CTL                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   AUTO_RFR_LEVEL0                = "
  tree.end
  tree "GSBI1_UART_DM_MR2"
   group.long 0x4--0x7 "GSBI1_UART_DM_MR2 (at 0xa2000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LOOPBACK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_MODE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BITS_PER_CHAR                  = " "0 (5_BITS),1 (6_BITS),2 (7_BITS),3 (8_BITS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   STOP_BIT_LEN                   = " "0 (0_563),1 (1_000_BIT_TIME),2 (1_563),3 (2_000_BIT_TIMES) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PARITY_MODE                    = " "0 (NO_PARITY),1 (ODD_PARITY),2 (EVEN_PARITY),3 (SPACE_PARITY) "
  tree.end
  tree "GSBI1_UART_DM_CSR"
   group.long 0x8--0xb "GSBI1_UART_DM_CSR (at 0xa2000008)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_CSR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UART_RX_CLK_SEL                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   UART_TX_CLK_SEL                = "
  tree.end
  tree "GSBI1_UART_DM_TF"
   group.long 0x70--0x73 "GSBI1_UART_DM_TF (at 0xa2000070)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_TF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI1_UART_DM_TF_2"
   group.long 0x74--0x77 "GSBI1_UART_DM_TF_2 (at 0xa2000074)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_TF_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI1_UART_DM_TF_3"
   group.long 0x78--0x7b "GSBI1_UART_DM_TF_3 (at 0xa2000078)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_TF_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI1_UART_DM_TF_4"
   group.long 0x7c--0x7f "GSBI1_UART_DM_TF_4 (at 0xa200007c)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_TF_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI1_UART_DM_CR"
   group.long 0x10--0x13 "GSBI1_UART_DM_CR (at 0xa2000010)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_CR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CHANNEL_COMMAND_MSB            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GENERAL_COMMAND                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHANNEL_COMMAND_LSB            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UART_TX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UART_TX_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UART_RX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UART_RX_EN                     = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_IMR"
   group.long 0x14--0x17 "GSBI1_UART_DM_IMR (at 0xa2000014)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_IMR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_IPR"
   group.long 0x18--0x1b "GSBI1_UART_DM_IPR (at 0xa2000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   STALE_TIMEOUT_MSB              = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_DATA                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STALE_TIMEOUT_LSB              = "
  tree.end
  tree "GSBI1_UART_DM_TFWR"
   group.long 0x1c--0x1f "GSBI1_UART_DM_TFWR (at 0xa200001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TFW                            = "
  tree.end
  tree "GSBI1_UART_DM_RFWR"
   group.long 0x20--0x23 "GSBI1_UART_DM_RFWR (at 0xa2000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RFW                            = "
  tree.end
  tree "GSBI1_UART_DM_HCR"
   group.long 0x24--0x27 "GSBI1_UART_DM_HCR (at 0xa2000024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "GSBI1_UART_DM_DMRX"
   group.long 0x34--0x37 "GSBI1_UART_DM_DMRX (at 0xa2000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   RX_DM_CRCI_CHARS               = "
  tree.end
  tree "GSBI1_UART_DM_IRDA"
   group.long 0x38--0x3b "GSBI1_UART_DM_IRDA (at 0xa2000038)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_IRDA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MEDIUM_RATE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   IRDA_LOOPBACK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_IRDA_TX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INVERT_IRDA_RX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRDA_EN                        = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_DMEN"
   group.long 0x3c--0x3f "GSBI1_UART_DM_DMEN (at 0xa200003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX_DM_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DM_EN                       = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_NO_CHARS_FOR_TX"
   group.long 0x40--0x43 "GSBI1_UART_DM_NO_CHARS_FOR_TX (at 0xa2000040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   TX_TOTAL_TRANS_LEN             = "
  tree.end
  tree "GSBI1_UART_DM_BADR"
   group.long 0x44--0x47 "GSBI1_UART_DM_BADR (at 0xa2000044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RX_BASE_ADDR                   = "
  tree.end
  tree "GSBI1_UART_DM_TESTSL"
   group.long 0x48--0x4b "GSBI1_UART_DM_TESTSL (at 0xa2000048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_EN                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_SEL                       = "
  tree.end
  tree "GSBI1_UART_DM_MISR_MODE"
   group.long 0x60--0x63 "GSBI1_UART_DM_MISR_MODE (at 0xa2000060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                           = " "0 (DISABLED),1 (ENABLED_TX_TEST),2 (ENABLED_RX_TEST),3 (reserved) "
  tree.end
  tree "GSBI1_UART_DM_MISR_RESET"
   group.long 0x64--0x67 "GSBI1_UART_DM_MISR_RESET (at 0xa2000064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_MISR_EXPORT"
   group.long 0x68--0x6b "GSBI1_UART_DM_MISR_EXPORT (at 0xa2000068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXPORT                         = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_MISR_VAL"
   group.long 0x6c--0x6f "GSBI1_UART_DM_MISR_VAL (at 0xa200006c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   VAL                            = "
  tree.end
  tree "GSBI1_UART_DM_SIM_CFG"
   group.long 0x80--0x83 "GSBI1_UART_DM_SIM_CFG (at 0xa2000080)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_SIM_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   UIM_TX_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   UIM_RX_MODE                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SIM_STOP_BIT_LEN               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SIM_CLK_ON                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SIM_CLK_TD8_SEL                = " "0 (TD4),1 (TD8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SIM_CLK_STOP_HIGH              = " "0 (LOW),1 (HIGH) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SIM_CLK_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_RX                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SWAP_D                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INV_D                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SIM_SEL                        = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_TEST_WR_ADDR"
   group.long 0x84--0x87 "GSBI1_UART_DM_TEST_WR_ADDR (at 0xa2000084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_ADDR                   = "
  tree.end
  tree "GSBI1_UART_DM_TEST_WR_DATA"
   group.long 0x88--0x8b "GSBI1_UART_DM_TEST_WR_DATA (at 0xa2000088)   (shadowed - Use hwio_shadow_ptr->GSBI1_UART_DM_TEST_WR_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_DATA                   = "
  tree.end
  tree "GSBI1_UART_DM_TEST_RD_ADDR"
   group.long 0x8c--0x8f "GSBI1_UART_DM_TEST_RD_ADDR (at 0xa200008c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_ADDR                   = "
  tree.end
  tree "GSBI1_UART_DM_SR"
   group.long 0x8--0xb "GSBI1_UART_DM_SR (at 0xa2000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   HUNT_CHAR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RX_BREAK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PAR_FRAME_ERR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UART_OVERRUN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TXEMT                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TXRDY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXFULL                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RXRDY                          = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_RF"
   group.long 0x70--0x73 "GSBI1_UART_DM_RF (at 0xa2000070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI1_UART_DM_RF_2"
   group.long 0x74--0x77 "GSBI1_UART_DM_RF_2 (at 0xa2000074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI1_UART_DM_RF_3"
   group.long 0x78--0x7b "GSBI1_UART_DM_RF_3 (at 0xa2000078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI1_UART_DM_RF_4"
   group.long 0x7c--0x7f "GSBI1_UART_DM_RF_4 (at 0xa200007c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI1_UART_DM_MISR"
   group.long 0x10--0x13 "GSBI1_UART_DM_MISR (at 0xa2000010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   UART_MISR                      = "
  tree.end
  tree "GSBI1_UART_DM_ISR"
   group.long 0x14--0x17 "GSBI1_UART_DM_ISR (at 0xa2000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI1_UART_DM_RX_TOTAL_SNAP"
   group.long 0x38--0x3b "GSBI1_UART_DM_RX_TOTAL_SNAP (at 0xa2000038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RX_TOTAL_BYTES                 = "
  tree.end
  tree "GSBI1_UART_DM_TXFS"
   group.long 0x4c--0x4f "GSBI1_UART_DM_TXFS (at 0xa200004c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   TX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   TX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI1_UART_DM_RXFS"
   group.long 0x50--0x53 "GSBI1_UART_DM_RXFS (at 0xa2000050)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   RX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI1_UART_DM_TEST_RD_DATA"
   group.long 0x90--0x93 "GSBI1_UART_DM_TEST_RD_DATA (at 0xa2000090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_DATA                   = "
  tree.end
tree.end

base ad:0xa8000000
tree "GSBI2_GSBI2_CTRL"
  tree "GSBI2_GSBI_CTRL_REG"
   group.long 0x0--0x3 "GSBI2_GSBI_CTRL_REG (at 0xa8000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DEBUG                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   PROTOCOL_CODE                  = " "0 (IDLE),1 (AUDIO),2 (I2CC),3 (SPI),4 (UART),5 (R_UIM),6 (UARTZ),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CLOCK_ENABLE3                  = " "0 (DISABLE_SPI_CLOCK),1 (ENABLE_SPI_CLOCK) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CLOCK_ENABLE2                  = " "0 (DISABLE_I2CC_CLOCK),1 (ENABLE_I2CC_CLOCK) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CLOCK_ENABLE1                  = " "0 (DISABLE_UART_DM_CLOCK),1 (ENABLE_UART_DM_CLOCK) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   SPI_CHIP_SELECTS               = " "0 (DISABLE_EXTRA_SPI_CHIP_SELECTS),1 (ENABLE_EXTRA_SPI_CHIP_SELECTS) "
  tree.end
  tree "GSBI2_GSBI_DBG0_REG"
   group.long 0x4--0x7 "GSBI2_GSBI_DBG0_REG (at 0xa8000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY0                     = " "0,1,2,3 "
  tree.end
  tree "GSBI2_GSBI_DBG1_REG"
   group.long 0x8--0xb "GSBI2_GSBI_DBG1_REG (at 0xa8000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY1                     = " "0,1,2,3 "
  tree.end
  tree "GSBI2_GSBI_DBG2_REG"
   group.long 0xc--0xf "GSBI2_GSBI_DBG2_REG (at 0xa800000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI_PLAY2                     = " "0,1,2,3 "
  tree.end
  tree "GSBI2_GSBI_DBG3_REG"
   group.long 0x10--0x13 "GSBI2_GSBI_DBG3_REG (at 0xa8000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GSBI                           = " "0,1,2,3 "
  tree.end
tree.end

base ad:0xac000000
tree "GSBI2_GSBI2_I2C"
  tree "GSBI2_I2C_WRITE_DATA"
   group.long 0x0--0x3 "GSBI2_I2C_WRITE_DATA (at 0xac000000)   (shadowed - Use hwio_shadow_ptr->GSBI2_I2C_WRITE_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   LAST_BYTE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ADDR_BYTE                      = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI2_I2C_CLK_CTL"
   group.long 0x4--0x7 "GSBI2_I2C_CLK_CTL (at 0xac000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HS_DIVIDER_VALUE               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FS_DIVIDER_VALUE               = "
  tree.end
  tree "GSBI2_I2C_STATUS"
   group.long 0x8--0xb "GSBI2_I2C_STATUS (at 0xac000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   CLK_STATE                      = " "0 (RESET_BUSIDLE_STATE),1 (NOT_MASTER_STATE),2 (HIGH_STATE),3 (LOW_STATE),4 (HIGH_WAIT_STATE),5 (FORCED_LOW_STATE),6 (HS_ADDR_LOW_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0xa--0xc "  [12:10]   DATA_STATE                     = " "0 (RESET_WAIT_STATE),1 (TX_ADDR_STATE),2 (TX_DATA_STATE),3 (TX_HS_ADDR_STATE),4 (TX_10_BIT_ADDR_STATE),5 (TX_2ND_BYTE_STATE),6 (RX_DATA_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BUS_MASTER                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BUS_ACTIVE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FAILED                         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INVALID_WRITE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ARB_LOST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PACKET_NACKED                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BUS_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RD_BUFFER_FULL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WR_BUFFER_FULL                 = " "0,1 "
  tree.end
  tree "GSBI2_I2C_READ_DATA"
   group.long 0xc--0xf "GSBI2_I2C_READ_DATA (at 0xac00000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "GSBI2_I2C_INTERFACE_SELECT"
   group.long 0x10--0x13 "GSBI2_I2C_INTERFACE_SELECT (at 0xac000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SDA                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SCL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TEST_DATA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTF_SELECT                    = " "0,1 "
  tree.end
tree.end

base ad:0xae000000
tree "GSBI2_GSBI2_SPI"
  tree "GSBI2_SPI_CONFIG"
   group.long 0x0--0x3 "GSBI2_SPI_CONFIG (at 0xae000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_FIRST                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LOOP_BACK                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   NO_INPUT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   NO_OUTPUT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SLAVE_OPERATION                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   N                              = "
  tree.end
  tree "GSBI2_SPI_IO_CONTROL"
   group.long 0x4--0x7 "GSBI2_SPI_IO_CONTROL (at 0xae000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CLK_IDLE_HIGH                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CLK_ALWAYS_ON                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MX_CS_MODE                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CS_N_POLARITY                  = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TRISTATE_CS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   NO_TRI_STATE                   = " "0,1 "
  tree.end
  tree "GSBI2_SPI_IO_MODES"
   group.long 0x8--0xb "GSBI2_SPI_IO_MODES (at 0xae000008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   OUTPUT_BIT_SHIFT_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PACK_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   UNPACK_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   INPUT_MODE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   OUTPUT_MODE                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   INPUT_FIFO_SIZE                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   INPUT_BLOCK_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OUTPUT_FIFO_SIZE               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_BLOCK_SIZE              = " "0,1,2,3 "
  tree.end
  tree "GSBI2_SPI_SW_RESET"
   group.long 0xc--0xf "GSBI2_SPI_SW_RESET (at 0xae00000c)   (shadowed - Use hwio_shadow_ptr->GSBI2_SPI_SW_RESET to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "GSBI2_SPI_TIME_OUT"
   group.long 0x10--0x13 "GSBI2_SPI_TIME_OUT (at 0xae000010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_VALUE                 = "
  tree.end
  tree "GSBI2_SPI_TIME_OUT_CURRENT"
   group.long 0x14--0x17 "GSBI2_SPI_TIME_OUT_CURRENT (at 0xae000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TIME_OUT_CURRENT               = "
  tree.end
  tree "GSBI2_SPI_MX_OUTPUT_COUNT"
   group.long 0x18--0x1b "GSBI2_SPI_MX_OUTPUT_COUNT (at 0xae000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_COUNT                = "
  tree.end
  tree "GSBI2_SPI_MX_OUTPUT_CNT_CURRENT"
   group.long 0x1c--0x1f "GSBI2_SPI_MX_OUTPUT_CNT_CURRENT (at 0xae00001c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_OUTPUT_CNT_CURRENT          = "
  tree.end
  tree "GSBI2_SPI_MX_INPUT_COUNT"
   group.long 0x20--0x23 "GSBI2_SPI_MX_INPUT_COUNT (at 0xae000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_COUNT                 = "
  tree.end
  tree "GSBI2_SPI_MX_INPUT_CNT_CURRENT"
   group.long 0x24--0x27 "GSBI2_SPI_MX_INPUT_CNT_CURRENT (at 0xae000024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MX_INPUT_CNT_CURRENT           = "
  tree.end
  tree "GSBI2_SPI_MX_READ_COUNT"
   group.long 0x28--0x2b "GSBI2_SPI_MX_READ_COUNT (at 0xae000028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_COUNT                  = "
  tree.end
  tree "GSBI2_SPI_MX_READ_CNT_CURRENT"
   group.long 0x2c--0x2f "GSBI2_SPI_MX_READ_CNT_CURRENT (at 0xae00002c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   MX_READ_CNT_CURRENT            = "
  tree.end
  tree "GSBI2_SPI_OPERATIONAL"
   group.long 0x30--0x33 "GSBI2_SPI_OPERATIONAL (at 0xae000030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MAX_INPUT_DONE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MAX_OUTPUT_DONE_FLAG           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   INPUT_SERVICE_FLAG             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   OUTPUT_SERVICE_FLAG            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_FIFO_FULL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   OUTPUT_FIFO_FULL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_FIFO_NOT_EMPTY           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   OUTPUT_FIFO_NOT_EMPTY          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   STATE_VALID                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STATE                          = " "0,1,2,3 "
  tree.end
  tree "GSBI2_SPI_ERROR_FLAGS"
   group.long 0x34--0x37 "GSBI2_SPI_ERROR_FLAGS (at 0xae000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR              = " "0,1 "
  tree.end
  tree "GSBI2_SPI_ERROR_FLAGS_EN"
   group.long 0x38--0x3b "GSBI2_SPI_ERROR_FLAGS_EN (at 0xae000038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TIME_OUT_ERR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   OUTPUT_OVER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_UNDER_RUN_ERR_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OUTPUT_UNDER_RUN_ERR_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INPUT_OVER_RUN_ERR_EN          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_OVER_RUN_ERR_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_UNDER_RUN_ERR_EN           = " "0,1 "
  tree.end
  tree "GSBI2_SPI_DEASSERT_WAIT"
   group.long 0x3c--0x3f "GSBI2_SPI_DEASSERT_WAIT (at 0xae00003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DEASSERT_WAIT                  = "
  tree.end
  tree "GSBI2_SPI_OUTPUT_DEBUG"
   group.long 0x40--0x43 "GSBI2_SPI_OUTPUT_DEBUG (at 0xae000040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT_DEBUG_DATA              = "
  tree.end
  tree "GSBI2_SPI_INPUT_DEBUG"
   group.long 0x44--0x47 "GSBI2_SPI_INPUT_DEBUG (at 0xae000044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT_DEBUG_DATA               = "
  tree.end
  tree "GSBI2_SPI_FIFO_WORD_CNT"
   group.long 0x48--0x4b "GSBI2_SPI_FIFO_WORD_CNT (at 0xae000048)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   INPUT_FIFO_WORD_CNT            = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   OUTPUT_FIFO_WORD_CNT           = "
  tree.end
  tree "GSBI2_SPI_TEST_CTRL"
   group.long 0x4c--0x4f "GSBI2_SPI_TEST_CTRL (at 0xae00004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SPI_TEST_BUS_EN                = " "0,1 "
  tree.end
  tree "GSBI2_SPI_OUTPUT_FIFO"
   group.long 0x100--0x103 "GSBI2_SPI_OUTPUT_FIFO (at 0xae000100)   (shadowed - Use hwio_shadow_ptr->GSBI2_SPI_OUTPUT_FIFO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   OUTPUT                         = "
  tree.end
  tree "GSBI2_SPI_INPUT_FIFO"
   group.long 0x200--0x203 "GSBI2_SPI_INPUT_FIFO (at 0xae000200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   INPUT                          = "
  tree.end
tree.end

base ad:0xaa000000
tree "GSBI2_GSBI2_UART"
  tree "GSBI2_UART_DM_MR1"
   group.long 0x0--0x3 "GSBI2_UART_DM_MR1 (at 0xaa000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x8--0x1f 1 "  [31: 8]   AUTO_RFR_LEVEL1                = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RX_RDY_CTL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CTS_CTL                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   AUTO_RFR_LEVEL0                = "
  tree.end
  tree "GSBI2_UART_DM_MR2"
   group.long 0x4--0x7 "GSBI2_UART_DM_MR2 (at 0xaa000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LOOPBACK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_MODE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BITS_PER_CHAR                  = " "0 (5_BITS),1 (6_BITS),2 (7_BITS),3 (8_BITS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   STOP_BIT_LEN                   = " "0 (0_563),1 (1_000_BIT_TIME),2 (1_563),3 (2_000_BIT_TIMES) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PARITY_MODE                    = " "0 (NO_PARITY),1 (ODD_PARITY),2 (EVEN_PARITY),3 (SPACE_PARITY) "
  tree.end
  tree "GSBI2_UART_DM_CSR"
   group.long 0x8--0xb "GSBI2_UART_DM_CSR (at 0xaa000008)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_CSR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UART_RX_CLK_SEL                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   UART_TX_CLK_SEL                = "
  tree.end
  tree "GSBI2_UART_DM_TF"
   group.long 0x70--0x73 "GSBI2_UART_DM_TF (at 0xaa000070)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_TF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI2_UART_DM_TF_2"
   group.long 0x74--0x77 "GSBI2_UART_DM_TF_2 (at 0xaa000074)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_TF_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI2_UART_DM_TF_3"
   group.long 0x78--0x7b "GSBI2_UART_DM_TF_3 (at 0xaa000078)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_TF_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI2_UART_DM_TF_4"
   group.long 0x7c--0x7f "GSBI2_UART_DM_TF_4 (at 0xaa00007c)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_TF_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "GSBI2_UART_DM_CR"
   group.long 0x10--0x13 "GSBI2_UART_DM_CR (at 0xaa000010)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_CR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CHANNEL_COMMAND_MSB            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GENERAL_COMMAND                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHANNEL_COMMAND_LSB            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UART_TX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UART_TX_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UART_RX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UART_RX_EN                     = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_IMR"
   group.long 0x14--0x17 "GSBI2_UART_DM_IMR (at 0xaa000014)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_IMR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_IPR"
   group.long 0x18--0x1b "GSBI2_UART_DM_IPR (at 0xaa000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   STALE_TIMEOUT_MSB              = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_DATA                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STALE_TIMEOUT_LSB              = "
  tree.end
  tree "GSBI2_UART_DM_TFWR"
   group.long 0x1c--0x1f "GSBI2_UART_DM_TFWR (at 0xaa00001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TFW                            = "
  tree.end
  tree "GSBI2_UART_DM_RFWR"
   group.long 0x20--0x23 "GSBI2_UART_DM_RFWR (at 0xaa000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RFW                            = "
  tree.end
  tree "GSBI2_UART_DM_HCR"
   group.long 0x24--0x27 "GSBI2_UART_DM_HCR (at 0xaa000024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "GSBI2_UART_DM_DMRX"
   group.long 0x34--0x37 "GSBI2_UART_DM_DMRX (at 0xaa000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   RX_DM_CRCI_CHARS               = "
  tree.end
  tree "GSBI2_UART_DM_IRDA"
   group.long 0x38--0x3b "GSBI2_UART_DM_IRDA (at 0xaa000038)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_IRDA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MEDIUM_RATE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   IRDA_LOOPBACK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_IRDA_TX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INVERT_IRDA_RX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRDA_EN                        = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_DMEN"
   group.long 0x3c--0x3f "GSBI2_UART_DM_DMEN (at 0xaa00003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX_DM_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DM_EN                       = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_NO_CHARS_FOR_TX"
   group.long 0x40--0x43 "GSBI2_UART_DM_NO_CHARS_FOR_TX (at 0xaa000040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   TX_TOTAL_TRANS_LEN             = "
  tree.end
  tree "GSBI2_UART_DM_BADR"
   group.long 0x44--0x47 "GSBI2_UART_DM_BADR (at 0xaa000044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RX_BASE_ADDR                   = "
  tree.end
  tree "GSBI2_UART_DM_TESTSL"
   group.long 0x48--0x4b "GSBI2_UART_DM_TESTSL (at 0xaa000048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_EN                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_SEL                       = "
  tree.end
  tree "GSBI2_UART_DM_MISR_MODE"
   group.long 0x60--0x63 "GSBI2_UART_DM_MISR_MODE (at 0xaa000060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                           = " "0 (DISABLED),1 (ENABLED_TX_TEST),2 (ENABLED_RX_TEST),3 (reserved) "
  tree.end
  tree "GSBI2_UART_DM_MISR_RESET"
   group.long 0x64--0x67 "GSBI2_UART_DM_MISR_RESET (at 0xaa000064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_MISR_EXPORT"
   group.long 0x68--0x6b "GSBI2_UART_DM_MISR_EXPORT (at 0xaa000068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXPORT                         = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_MISR_VAL"
   group.long 0x6c--0x6f "GSBI2_UART_DM_MISR_VAL (at 0xaa00006c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   VAL                            = "
  tree.end
  tree "GSBI2_UART_DM_SIM_CFG"
   group.long 0x80--0x83 "GSBI2_UART_DM_SIM_CFG (at 0xaa000080)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_SIM_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   UIM_TX_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   UIM_RX_MODE                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SIM_STOP_BIT_LEN               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SIM_CLK_ON                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SIM_CLK_TD8_SEL                = " "0 (TD4),1 (TD8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SIM_CLK_STOP_HIGH              = " "0 (LOW),1 (HIGH) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SIM_CLK_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_RX                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SWAP_D                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INV_D                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SIM_SEL                        = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_TEST_WR_ADDR"
   group.long 0x84--0x87 "GSBI2_UART_DM_TEST_WR_ADDR (at 0xaa000084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_ADDR                   = "
  tree.end
  tree "GSBI2_UART_DM_TEST_WR_DATA"
   group.long 0x88--0x8b "GSBI2_UART_DM_TEST_WR_DATA (at 0xaa000088)   (shadowed - Use hwio_shadow_ptr->GSBI2_UART_DM_TEST_WR_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_DATA                   = "
  tree.end
  tree "GSBI2_UART_DM_TEST_RD_ADDR"
   group.long 0x8c--0x8f "GSBI2_UART_DM_TEST_RD_ADDR (at 0xaa00008c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_ADDR                   = "
  tree.end
  tree "GSBI2_UART_DM_SR"
   group.long 0x8--0xb "GSBI2_UART_DM_SR (at 0xaa000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   HUNT_CHAR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RX_BREAK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PAR_FRAME_ERR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UART_OVERRUN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TXEMT                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TXRDY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXFULL                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RXRDY                          = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_RF"
   group.long 0x70--0x73 "GSBI2_UART_DM_RF (at 0xaa000070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI2_UART_DM_RF_2"
   group.long 0x74--0x77 "GSBI2_UART_DM_RF_2 (at 0xaa000074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI2_UART_DM_RF_3"
   group.long 0x78--0x7b "GSBI2_UART_DM_RF_3 (at 0xaa000078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI2_UART_DM_RF_4"
   group.long 0x7c--0x7f "GSBI2_UART_DM_RF_4 (at 0xaa00007c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "GSBI2_UART_DM_MISR"
   group.long 0x10--0x13 "GSBI2_UART_DM_MISR (at 0xaa000010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   UART_MISR                      = "
  tree.end
  tree "GSBI2_UART_DM_ISR"
   group.long 0x14--0x17 "GSBI2_UART_DM_ISR (at 0xaa000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "GSBI2_UART_DM_RX_TOTAL_SNAP"
   group.long 0x38--0x3b "GSBI2_UART_DM_RX_TOTAL_SNAP (at 0xaa000038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RX_TOTAL_BYTES                 = "
  tree.end
  tree "GSBI2_UART_DM_TXFS"
   group.long 0x4c--0x4f "GSBI2_UART_DM_TXFS (at 0xaa00004c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   TX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   TX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI2_UART_DM_RXFS"
   group.long 0x50--0x53 "GSBI2_UART_DM_RXFS (at 0xaa000050)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   RX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RX_FIFO_STATE_LSB              = "
  tree.end
  tree "GSBI2_UART_DM_TEST_RD_DATA"
   group.long 0x90--0x93 "GSBI2_UART_DM_TEST_RD_DATA (at 0xaa000090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_DATA                   = "
  tree.end
tree.end
tree.end

base ad:0x80038000
tree "IBI_REGS"
 tree "IBIn_CFG"
  tree "IBI0_CFG"
   group.long 0x0--0x3 "IBI0_CFG (at 0x80038000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RESERVED_BIT5                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT0_POSTED_WR_OPT_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BURST_INCR_CFG                 = " "0 (4_WORD_BURSTS),1 (8_WORD_BURSTS),2 (16_WORD_BURSTS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESERVED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PWRSAVE_MODE                   = " "0,1 "
  tree.end
  tree "IBI1_CFG"
   group.long 0x4--0x7 "IBI1_CFG (at 0x80038004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RESERVED_BIT5                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PORT0_POSTED_WR_OPT_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BURST_INCR_CFG                 = " "0 (4_WORD_BURSTS),1 (8_WORD_BURSTS),2 (16_WORD_BURSTS),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESERVED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PWRSAVE_MODE                   = " "0,1 "
  tree.end
 tree.end
 tree "IBIn_AHB_PRIORITY"
  tree "IBI0_AHB_PRIORITY"
   group.long 0x10--0x13 "IBI0_AHB_PRIORITY (at 0x80038010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PORT1_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT0_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   PP_RR_SEL                      = " "0 (PROGRAMMABLE_PRIORITY),1 (ROUND_ROBIN) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   RESERVED_BIT9                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1) "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AHB1_PP_PRIORITY               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESERVED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   AHB0_PP_PRIORITY               = " "0,1 "
  tree.end
  tree "IBI1_AHB_PRIORITY"
   group.long 0x14--0x17 "IBI1_AHB_PRIORITY (at 0x80038014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PORT1_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PORT0_WRLOCK_ENA               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   PP_RR_SEL                      = " "0 (PROGRAMMABLE_PRIORITY),1 (ROUND_ROBIN) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   RESERVED_BIT9                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DEFAULT_AHB_BUS                = " "0 (AHB_PORT0),1 (AHB_PORT1) "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   RESERVED_BITS7_3               = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AHB1_PP_PRIORITY               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESERVED_BIT1                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   AHB0_PP_PRIORITY               = " "0,1 "
  tree.end
 tree.end
 tree "IMEMn_CFG"
  tree "IMEM0_CFG"
   group.long 0x20--0x23 "IMEM0_CFG (at 0x80038020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ACC                            = "
  tree.end
  tree "IMEM1_CFG"
   group.long 0x24--0x27 "IMEM1_CFG (at 0x80038024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ACC                            = "
  tree.end
  tree "IMEM2_CFG"
   group.long 0x28--0x2b "IMEM2_CFG (at 0x80038028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ACC                            = "
  tree.end
  tree "IMEM3_CFG"
   group.long 0x2c--0x2f "IMEM3_CFG (at 0x8003802c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ACC                            = "
  tree.end
 tree.end
  tree "IMEM0_BASE_ADDR"
   group.long 0x30--0x33 "IMEM0_BASE_ADDR (at 0x80038030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   BASE_ADDR                      = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RESERVED_BITS15_0              = "
  tree.end
  tree "IMEM1_BASE_ADDR"
   group.long 0x34--0x37 "IMEM1_BASE_ADDR (at 0x80038034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   BASE_ADDR                      = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RESERVED_BITS15_0              = "
  tree.end
  tree "IMEM2_BASE_ADDR"
   group.long 0x38--0x3b "IMEM2_BASE_ADDR (at 0x80038038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   BASE_ADDR                      = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RESERVED_BITS15_0              = "
  tree.end
  tree "IMEM3_BASE_ADDR"
   group.long 0x3c--0x3f "IMEM3_BASE_ADDR (at 0x8003803c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   BASE_ADDR                      = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RESERVED_BITS15_0              = "
  tree.end
  tree "IMEM_BASE_ADDR_EN"
   group.long 0x40--0x43 "IMEM_BASE_ADDR_EN (at 0x80038040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BASE_ADDR_EN                   = " "0,1 "
  tree.end
 tree "IBIn_DEBUG_BUS_CFG"
  tree "IBI0_DEBUG_BUS_CFG"
   group.long 0x50--0x53 "IBI0_DEBUG_BUS_CFG (at 0x80038050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   IMEM_CTLR_DBG_SEL              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   IMEM_CTLR_DBG_D31_D16_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   IMEM_CTLR_DBG_D15_D0_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   IMEM_CTLR_DBG_SWAP             = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   IBI_ARB_MUX_DBG_D31_D16_EN     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   IBI_ARB_MUX_DBG_D15_D0_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   IBI_ARB_MUX_DBG_SWAP           = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TWO_PORT_AHB_IF_DBG_SEL        = " "0 (PORT0_AHB_INTERFACE_DEBUG_SIGNALS),1 (PORT1_AHB_INTERFACE_DEBUG_SIGNALS),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWO_PORT_AHB_IF_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWO_PORT_AHB_IF_DBG_D15_D0_EN  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TWO_PORT_AHB_IF_DBG_SWAP       = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
  tree "IBI1_DEBUG_BUS_CFG"
   group.long 0x54--0x57 "IBI1_DEBUG_BUS_CFG (at 0x80038054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   IMEM_CTLR_DBG_SEL              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   IMEM_CTLR_DBG_D31_D16_EN       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   IMEM_CTLR_DBG_D15_D0_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   IMEM_CTLR_DBG_SWAP             = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   IBI_ARB_MUX_DBG_D31_D16_EN     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   IBI_ARB_MUX_DBG_D15_D0_EN      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   IBI_ARB_MUX_DBG_SWAP           = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TWO_PORT_AHB_IF_DBG_SEL        = " "0 (PORT0_AHB_INTERFACE_DEBUG_SIGNALS),1 (PORT1_AHB_INTERFACE_DEBUG_SIGNALS),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TWO_PORT_AHB_IF_DBG_D31_D16_EN = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TWO_PORT_AHB_IF_DBG_D15_D0_EN  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TWO_PORT_AHB_IF_DBG_SWAP       = " "0 (SWAP_DISABLED),1 (SWAP_ENABLED) "
  tree.end
 tree.end
 tree "IBIn_PROFILING_CFG"
  tree "IBI0_PROFILING_CFG"
   group.long 0x60--0x63 "IBI0_PROFILING_CFG (at 0x80038060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   HW_CNTR3_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   HW_CNTR2_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HW_CNTR1_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_CNTR0_MODE                  = "
  tree.end
  tree "IBI1_PROFILING_CFG"
   group.long 0x64--0x67 "IBI1_PROFILING_CFG (at 0x80038064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   HW_CNTR3_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   HW_CNTR2_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HW_CNTR1_MODE                  = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_CNTR0_MODE                  = "
  tree.end
 tree.end
tree.end
tree "INT"
base ad:0x80006000
tree "INT_CTL"
  tree "INT_POL_SET"
   group.long 0x40--0x43 "INT_POL_SET (at 0x80006040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   UART2_RX_DATA_INT              = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   UART1_RX_DATA_INT              = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   UART0_RX_DATA_INT              = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   UART_DM_RX_DATA_INT            = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   UART_DM_INT                    = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   UART2_INT                      = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   UART1_INT                      = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   UART0_INT                      = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   JD_INT                         = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   PM_INT_N                       = " "0 (PASSES_THE_SIGNAL_WIHOUT_INVERSION),1 (INVERTS_THE_INTERRUPT_SIGNAL) "
  tree.end
  tree "IRQ_EN_0"
   group.long 0x30--0x33 "IRQ_EN_0 (at 0x80006030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   UART2_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART1_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   UART0_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   UART_DM_RX_DATA_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   UART_DM_INT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MDP_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   CAMIF_PAD_REG_OVERFLOW         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   I2CC_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   I2CC2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UART2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SPI2_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SPI2_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SPI2_ERROR_IRQ                 = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MODEM_TO_ARM_INT               = "
  tree.end
  tree "IRQ_EN_1"
   group.long 0x34--0x37 "IRQ_EN_1 (at 0x80006034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SSBI_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   SPI1_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPI1_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SPI1_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPI0_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   SPI0_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SPI0_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   APP_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SYS_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SYS_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   APP_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BPM_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   JD_INT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   GPIO2_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   GPIO1_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_HS_IRQ                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ADSP_INT_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADSP_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   I2CC1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2CC0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   KEYSENSE_GROUP_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UART1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UART0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUX_CODEC_ONES_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SDCC_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SDCC_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TIME_TICK_INT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_TIME_TICK_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_TIMER_0_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_TIMER_1_INT              = " "0,1 "
  tree.end
  tree "FIQ_EN_0"
   group.long 0x38--0x3b "FIQ_EN_0 (at 0x80006038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   UART2_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART1_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   UART0_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   UART_DM_RX_DATA_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   UART_DM_INT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MDP_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   CAMIF_PAD_REG_OVERFLOW         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   I2CC_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   I2CC2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UART2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SPI2_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SPI2_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SPI2_ERROR_IRQ                 = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MODEM_TO_ARM_INT               = "
  tree.end
  tree "FIQ_EN_1"
   group.long 0x3c--0x3f "FIQ_EN_1 (at 0x8000603c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SSBI_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   SPI1_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPI1_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SPI1_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPI0_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   SPI0_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SPI0_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   APP_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SYS_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SYS_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   APP_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BPM_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   JD_INT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   GPIO2_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   GPIO1_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_HS_IRQ                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ADSP_INT_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADSP_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   I2CC1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2CC0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   KEYSENSE_GROUP_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UART1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UART0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUX_CODEC_ONES_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SDCC_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SDCC_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TIME_TICK_INT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_TIME_TICK_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_TIMER_0_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_TIMER_1_INT              = " "0,1 "
  tree.end
  tree "INT_DET_REG_0"
   group.long 0x58--0x5b "INT_DET_REG_0 (at 0x80006058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   UART2_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART1_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   UART0_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   UART_DM_RX_DATA_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   UART_DM_INT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MDP_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   CAMIF_PAD_REG_OVERFLOW         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   I2CC_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   I2CC2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UART2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SPI2_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SPI2_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SPI2_ERROR_IRQ                 = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MODEM_TO_ARM_INT               = "
  tree.end
  tree "INT_DET_REG_1"
   group.long 0x5c--0x5f "INT_DET_REG_1 (at 0x8000605c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SSBI_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   SPI1_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPI1_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SPI1_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPI0_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   SPI0_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SPI0_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   APP_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SYS_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SYS_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   APP_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BPM_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   JD_INT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   GPIO2_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   GPIO1_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_HS_IRQ                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ADSP_INT_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADSP_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   I2CC1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2CC0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   KEYSENSE_GROUP_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UART1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UART0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUX_CODEC_ONES_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SDCC_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SDCC_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TIME_TICK_INT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_TIME_TICK_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_TIMER_0_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_TIMER_1_INT              = " "0,1 "
  tree.end
  tree "IRQ_STATUS_0"
   group.long 0x74--0x77 "IRQ_STATUS_0 (at 0x80006074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   UART2_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART1_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   UART0_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   UART_DM_RX_DATA_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   UART_DM_INT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MDP_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   CAMIF_PAD_REG_OVERFLOW         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   I2CC_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   I2CC2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UART2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SPI2_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SPI2_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SPI2_ERROR_IRQ                 = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MODEM_TO_ARM_INT               = "
  tree.end
  tree "IRQ_STATUS_1"
   group.long 0x78--0x7b "IRQ_STATUS_1 (at 0x80006078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SSBI_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   SPI1_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPI1_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SPI1_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPI0_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   SPI0_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SPI0_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   APP_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SYS_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SYS_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   APP_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BPM_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   JD_INT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   GPIO2_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   GPIO1_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_HS_IRQ                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ADSP_INT_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADSP_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   I2CC1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2CC0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   KEYSENSE_GROUP_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UART1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UART0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUX_CODEC_ONES_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SDCC_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SDCC_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TIME_TICK_INT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_TIME_TICK_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_TIMER_0_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_TIMER_1_INT              = " "0,1 "
  tree.end
  tree "FIQ_STATUS_0"
   group.long 0x7c--0x7f "FIQ_STATUS_0 (at 0x8000607c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   UART2_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   UART1_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   UART0_RX_DATA_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   UART_DM_RX_DATA_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   UART_DM_INT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MDP_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   CAMIF_PAD_REG_OVERFLOW         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   I2CC_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   I2CC2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UART2_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SPI2_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SPI2_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SPI2_ERROR_IRQ                 = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MODEM_TO_ARM_INT               = "
  tree.end
  tree "FIQ_STATUS_1"
   group.long 0x80--0x83 "FIQ_STATUS_1 (at 0x80006080)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SSBI_INT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   SPI1_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPI1_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SPI1_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SPI0_INPUT_SERVICE_IRQ         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   SPI0_OUTPUT_SERVICE_IRQ        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   SPI0_ERROR_IRQ                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   APP_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   SYS_SEC_ERR                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SYS_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   APP_POINTER_WRAP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BPM_INT                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   JD_INT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   GPIO2_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   GPIO1_GROUP_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USB_HS_IRQ                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ADSP_INT_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   ADSP_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   ADSP_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   I2CC1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   I2CC0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   KEYSENSE_GROUP_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   UART1_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   UART0_INT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AUX_CODEC_ONES_INT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SDCC_INT_0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SDCC_INT_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TIME_TICK_INT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_TIME_TICK_INT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_TIMER_0_INT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_TIMER_1_INT              = " "0,1 "
  tree.end
  tree "IRQ_VEC_INDEX_RD"
   group.long 0x9c--0x9f "IRQ_VEC_INDEX_RD (at 0x8000609c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA5_0                        = "
  tree.end
  tree "IRQ_VEC_INDEX_PEND_RD"
   group.long 0xa0--0xa3 "IRQ_VEC_INDEX_PEND_RD (at 0x800060a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA5_0                        = "
  tree.end
  tree "IRQ_IN_SERVICE_RD"
   group.long 0xa4--0xa7 "IRQ_IN_SERVICE_RD (at 0x800060a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   LEVEL7                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   LEVEL6                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   LEVEL5                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   LEVEL4                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   LEVEL3                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   LEVEL2                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   LEVEL1                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   LEVEL0                         = " "0 (NOT_IN_SERVICE),1 (IN_SERVICE) "
  tree.end
  tree "IRQ_IN_STACK_RD"
   group.long 0xa8--0xab "IRQ_IN_STACK_RD (at 0x800060a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   LEVEL6                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   LEVEL5                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   LEVEL4                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   LEVEL3                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   LEVEL2                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   LEVEL1                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   LEVEL0                         = " "0 (NOT_IN_STACK),1 (IN_STACK) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   MAIN                           = " "0 (NOT_IN_STACK),1 (IN_STACK) "
  tree.end
 tree "INT_n_PRIORITY"
  tree "INT_0_PRIORITY"
   group.long 0xb0--0xb3 "INT_0_PRIORITY (at 0x800060b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_1_PRIORITY"
   group.long 0xb4--0xb7 "INT_1_PRIORITY (at 0x800060b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_2_PRIORITY"
   group.long 0xb8--0xbb "INT_2_PRIORITY (at 0x800060b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_3_PRIORITY"
   group.long 0xbc--0xbf "INT_3_PRIORITY (at 0x800060bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_4_PRIORITY"
   group.long 0xc0--0xc3 "INT_4_PRIORITY (at 0x800060c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_5_PRIORITY"
   group.long 0xc4--0xc7 "INT_5_PRIORITY (at 0x800060c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_6_PRIORITY"
   group.long 0xc8--0xcb "INT_6_PRIORITY (at 0x800060c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_7_PRIORITY"
   group.long 0xcc--0xcf "INT_7_PRIORITY (at 0x800060cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_8_PRIORITY"
   group.long 0xd0--0xd3 "INT_8_PRIORITY (at 0x800060d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_9_PRIORITY"
   group.long 0xd4--0xd7 "INT_9_PRIORITY (at 0x800060d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_10_PRIORITY"
   group.long 0xd8--0xdb "INT_10_PRIORITY (at 0x800060d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_11_PRIORITY"
   group.long 0xdc--0xdf "INT_11_PRIORITY (at 0x800060dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_12_PRIORITY"
   group.long 0xe0--0xe3 "INT_12_PRIORITY (at 0x800060e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_13_PRIORITY"
   group.long 0xe4--0xe7 "INT_13_PRIORITY (at 0x800060e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_14_PRIORITY"
   group.long 0xe8--0xeb "INT_14_PRIORITY (at 0x800060e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_15_PRIORITY"
   group.long 0xec--0xef "INT_15_PRIORITY (at 0x800060ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_16_PRIORITY"
   group.long 0xf0--0xf3 "INT_16_PRIORITY (at 0x800060f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_17_PRIORITY"
   group.long 0xf4--0xf7 "INT_17_PRIORITY (at 0x800060f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_18_PRIORITY"
   group.long 0xf8--0xfb "INT_18_PRIORITY (at 0x800060f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_19_PRIORITY"
   group.long 0xfc--0xff "INT_19_PRIORITY (at 0x800060fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_20_PRIORITY"
   group.long 0x100--0x103 "INT_20_PRIORITY (at 0x80006100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_21_PRIORITY"
   group.long 0x104--0x107 "INT_21_PRIORITY (at 0x80006104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_22_PRIORITY"
   group.long 0x108--0x10b "INT_22_PRIORITY (at 0x80006108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_23_PRIORITY"
   group.long 0x10c--0x10f "INT_23_PRIORITY (at 0x8000610c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_24_PRIORITY"
   group.long 0x110--0x113 "INT_24_PRIORITY (at 0x80006110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_25_PRIORITY"
   group.long 0x114--0x117 "INT_25_PRIORITY (at 0x80006114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_26_PRIORITY"
   group.long 0x118--0x11b "INT_26_PRIORITY (at 0x80006118) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_27_PRIORITY"
   group.long 0x11c--0x11f "INT_27_PRIORITY (at 0x8000611c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_28_PRIORITY"
   group.long 0x120--0x123 "INT_28_PRIORITY (at 0x80006120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_29_PRIORITY"
   group.long 0x124--0x127 "INT_29_PRIORITY (at 0x80006124) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_30_PRIORITY"
   group.long 0x128--0x12b "INT_30_PRIORITY (at 0x80006128) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_31_PRIORITY"
   group.long 0x12c--0x12f "INT_31_PRIORITY (at 0x8000612c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_32_PRIORITY"
   group.long 0x130--0x133 "INT_32_PRIORITY (at 0x80006130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_33_PRIORITY"
   group.long 0x134--0x137 "INT_33_PRIORITY (at 0x80006134) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_34_PRIORITY"
   group.long 0x138--0x13b "INT_34_PRIORITY (at 0x80006138) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_35_PRIORITY"
   group.long 0x13c--0x13f "INT_35_PRIORITY (at 0x8000613c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_36_PRIORITY"
   group.long 0x140--0x143 "INT_36_PRIORITY (at 0x80006140) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_37_PRIORITY"
   group.long 0x144--0x147 "INT_37_PRIORITY (at 0x80006144) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_38_PRIORITY"
   group.long 0x148--0x14b "INT_38_PRIORITY (at 0x80006148) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_39_PRIORITY"
   group.long 0x14c--0x14f "INT_39_PRIORITY (at 0x8000614c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_40_PRIORITY"
   group.long 0x150--0x153 "INT_40_PRIORITY (at 0x80006150) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_41_PRIORITY"
   group.long 0x154--0x157 "INT_41_PRIORITY (at 0x80006154) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_42_PRIORITY"
   group.long 0x158--0x15b "INT_42_PRIORITY (at 0x80006158) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_43_PRIORITY"
   group.long 0x15c--0x15f "INT_43_PRIORITY (at 0x8000615c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_44_PRIORITY"
   group.long 0x160--0x163 "INT_44_PRIORITY (at 0x80006160) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_45_PRIORITY"
   group.long 0x164--0x167 "INT_45_PRIORITY (at 0x80006164) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_46_PRIORITY"
   group.long 0x168--0x16b "INT_46_PRIORITY (at 0x80006168) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_47_PRIORITY"
   group.long 0x16c--0x16f "INT_47_PRIORITY (at 0x8000616c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_48_PRIORITY"
   group.long 0x170--0x173 "INT_48_PRIORITY (at 0x80006170) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_49_PRIORITY"
   group.long 0x174--0x177 "INT_49_PRIORITY (at 0x80006174) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_50_PRIORITY"
   group.long 0x178--0x17b "INT_50_PRIORITY (at 0x80006178) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_51_PRIORITY"
   group.long 0x17c--0x17f "INT_51_PRIORITY (at 0x8000617c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_52_PRIORITY"
   group.long 0x180--0x183 "INT_52_PRIORITY (at 0x80006180) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_53_PRIORITY"
   group.long 0x184--0x187 "INT_53_PRIORITY (at 0x80006184) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_54_PRIORITY"
   group.long 0x188--0x18b "INT_54_PRIORITY (at 0x80006188) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_55_PRIORITY"
   group.long 0x18c--0x18f "INT_55_PRIORITY (at 0x8000618c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_56_PRIORITY"
   group.long 0x190--0x193 "INT_56_PRIORITY (at 0x80006190) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_57_PRIORITY"
   group.long 0x194--0x197 "INT_57_PRIORITY (at 0x80006194) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_58_PRIORITY"
   group.long 0x198--0x19b "INT_58_PRIORITY (at 0x80006198) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
  tree "INT_59_PRIORITY"
   group.long 0x19c--0x19f "INT_59_PRIORITY (at 0x8000619c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY                       = " "0 (LOWEST),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (HIGHEST) "
  tree.end
 tree.end
  tree "MSM_GPIO1_INT_EN_0"
   group.long 0x1a0--0x1a3 "MSM_GPIO1_INT_EN_0 (at 0x800061a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1b--0x1f 1 "  [31:27]   GPIO_INT_59_55                 = "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GPIO_INT_53                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x12--0x19 1 "  [25:18]   GPIO_INT_41_34                 = "
    textline ""
    hexmask.long.long 0x0 0x1--0x11 1 "  [17: 1]   GPIO_INT_30_14                 = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_INT_12                    = " "0,1 "
  tree.end
  tree "MSM_GPIO1_INT_POLARITY_0"
   group.long 0x1b4--0x1b7 "MSM_GPIO1_INT_POLARITY_0 (at 0x800061b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1b--0x1f 1 "  [31:27]   GPIO_INT_59_55                 = "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GPIO_INT_53                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x12--0x19 1 "  [25:18]   GPIO_INT_41_34                 = "
    textline ""
    hexmask.long.long 0x0 0x1--0x11 1 "  [17: 1]   GPIO_INT_30_14                 = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_INT_12                    = " "0,1 "
  tree.end
  tree "MSM_GPIO1_DETECT_CTL_0"
   group.long 0x1c8--0x1cb "MSM_GPIO1_DETECT_CTL_0 (at 0x800061c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1b--0x1f 1 "  [31:27]   GPIO_INT_59_55                 = "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GPIO_INT_53                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x12--0x19 1 "  [25:18]   GPIO_INT_41_34                 = "
    textline ""
    hexmask.long.long 0x0 0x1--0x11 1 "  [17: 1]   GPIO_INT_30_14                 = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_INT_12                    = " "0,1 "
  tree.end
  tree "MSM_GPIO1_INT_STATUS_0"
   group.long 0x1dc--0x1df "MSM_GPIO1_INT_STATUS_0 (at 0x800061dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1b--0x1f 1 "  [31:27]   GPIO_INT_59_55                 = "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GPIO_INT_53                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x12--0x19 1 "  [25:18]   GPIO_INT_41_34                 = "
    textline ""
    hexmask.long.long 0x0 0x1--0x11 1 "  [17: 1]   GPIO_INT_30_14                 = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_INT_12                    = " "0,1 "
  tree.end
  tree "MSM_GPIO1_INT_EN_1"
   group.long 0x1f4--0x1f7 "MSM_GPIO1_INT_EN_1 (at 0x800061f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   GPIO_INT_62_60                 = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MSM_GPIO1_INT_POLARITY_1"
   group.long 0x1f8--0x1fb "MSM_GPIO1_INT_POLARITY_1 (at 0x800061f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   GPIO_INT_62_60                 = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MSM_GPIO1_DETECT_CTL_1"
   group.long 0x1fc--0x1ff "MSM_GPIO1_DETECT_CTL_1 (at 0x800061fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   GPIO_INT_62_60                 = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MSM_GPIO1_INT_STATUS_1"
   group.long 0x200--0x203 "MSM_GPIO1_INT_STATUS_1 (at 0x80006200)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   GPIO_INT_62_60                 = " "0,1,2,3,4,5,6,7 "
  tree.end
tree.end

base ad:0x84006000
tree "INT_CTL_GPIO2"
  tree "MSM_INT_EN"
   group.long 0x178--0x17b "MSM_INT_EN (at 0x84006178) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   KEYSENSE_INT                   = " "0,1 "
  tree.end
  tree "MSM_INT_POLARITY"
   group.long 0x17c--0x17f "MSM_INT_POLARITY (at 0x8400617c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   KEYSENSE_INT                   = " "0,1 "
  tree.end
  tree "MSM_DETECT_CTL"
   group.long 0x180--0x183 "MSM_DETECT_CTL (at 0x84006180) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   KEYSENSE_INT                   = " "0,1 "
  tree.end
  tree "MSM_INT_STATUS"
   group.long 0x184--0x187 "MSM_INT_STATUS (at 0x84006184)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   KEYSENSE_INT                   = " "0,1 "
  tree.end
  tree "MSM_KEYSENSE_GROUP_STATUS"
   group.long 0x188--0x18b "MSM_KEYSENSE_GROUP_STATUS (at 0x84006188)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   KEYSENSE_GROUP                 = "
  tree.end
  tree "MSM_GPIO2_INT_EN"
   group.long 0x1a8--0x1ab "MSM_GPIO2_INT_EN (at 0x840061a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPIO_INT_54                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GPIO_INT_52_42                 = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   GPIO_INT_33_31                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_INT_13                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_INT_11_0                  = "
  tree.end
  tree "MSM_GPIO2_INT_POLARITY"
   group.long 0x1bc--0x1bf "MSM_GPIO2_INT_POLARITY (at 0x840061bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPIO_INT_54                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GPIO_INT_52_42                 = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   GPIO_INT_33_31                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_INT_13                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_INT_11_0                  = "
  tree.end
  tree "MSM_GPIO2_DETECT_CTL"
   group.long 0x1d0--0x1d3 "MSM_GPIO2_DETECT_CTL (at 0x840061d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPIO_INT_54                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GPIO_INT_52_42                 = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   GPIO_INT_33_31                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_INT_13                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_INT_11_0                  = "
  tree.end
  tree "MSM_GPIO2_INT_STATUS"
   group.long 0x1e4--0x1e7 "MSM_GPIO2_INT_STATUS (at 0x840061e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPIO_INT_54                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1a 1 "  [26:16]   GPIO_INT_52_42                 = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   GPIO_INT_33_31                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPIO_INT_13                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   GPIO_INT_11_0                  = "
  tree.end
tree.end
tree.end

base ad:0x8001e000
tree "MDP"
  tree "MDP_TEST_MODE"
   group.long 0x0--0x3 "MDP_TEST_MODE (at 0x8001e000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   RESERVED_BITS23_16             = "
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   RESERVED_BITS15_10             = "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DBG_BUS_SEL                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   VALUES_9_0                     = "
  tree.end
  tree "MDP_COMMAND"
   group.long 0x4--0x7 "MDP_COMMAND (at 0x8001e004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x3--0x1f 1 "  [31: 3]   RESERVED_BITS31_3              = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MDP_CMD_VAL                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDP_SCRIPT_ADDR"
   group.long 0x8--0xb "MDP_SCRIPT_ADDR (at 0x8001e008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIP_START_ADDR                 = "
  tree.end
  tree "MDP_CGC_CONFIG"
   group.long 0xc--0xf "MDP_CGC_CONFIG (at 0x8001e00c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xd--0x1f 1 "  [31:13]   RESERVED_BITS31_13             = "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   AIB_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CIP_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   FFR_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   GFX_ADDR_ON                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LUMA_ADDR_ON                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CHROMA_ADDR_ON                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SCALE_ON                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CCS_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BBB_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MBC_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   VDB_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RPB_ON                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SST_ON                         = " "0,1 "
  tree.end
  tree "MDP_SYNC_CONFIG"
   group.long 0x10--0x13 "MDP_SYNC_CONFIG (at 0x8001e010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x12--0x1f 1 "  [31:18]   RESERVED_BITS31_18             = "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   SST_SEL_VSYNC                  = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SST_TERM_DIV_CNT               = "
  tree.end
  tree "MDP_SYNC_STATUS"
   group.long 0x14--0x17 "MDP_SYNC_STATUS (at 0x8001e014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   FRAME_COUNT                    = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   RESERVED_BITS15_12             = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   LINE_COUNT                     = "
  tree.end
  tree "MDP_SST_REFRESH_COUNT"
   group.long 0x18--0x1b "MDP_SST_REFRESH_COUNT (at 0x8001e018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   REFRESH_COUNT                  = "
  tree.end
  tree "MDP_SCRIPT_STATUS"
   group.long 0x1c--0x1f "MDP_SCRIPT_STATUS (at 0x8001e01c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS31_1              = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SCRIPT_STATUS                  = " "0,1 "
  tree.end
  tree "MDP_INTR_ENABLE"
   group.long 0x20--0x23 "MDP_INTR_ENABLE (at 0x8001e020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   RESERVED_BITS31_7              = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   INT_ENABLE                     = "
  tree.end
  tree "MDP_INTR_STATUS"
   group.long 0x24--0x27 "MDP_INTR_STATUS (at 0x8001e024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   RESERVED_BITS31_7              = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STATUS                         = "
  tree.end
  tree "MDP_INTR_CLEAR"
   group.long 0x28--0x2b "MDP_INTR_CLEAR (at 0x8001e028)   (shadowed - Use hwio_shadow_ptr->MDP_INTR_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   RESERVED_BITS31_7              = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CLEAR                          = "
  tree.end
  tree "MDP_TEST_MISR_RESET"
   group.long 0x2c--0x2f "MDP_TEST_MISR_RESET (at 0x8001e02c)   (shadowed - Use hwio_shadow_ptr->MDP_TEST_MISR_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS_31_1             = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "MDP_TEST_EXPORT_MISR"
   group.long 0x30--0x33 "MDP_TEST_EXPORT_MISR (at 0x8001e030)   (shadowed - Use hwio_shadow_ptr->MDP_TEST_EXPORT_MISR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x1--0x1f 1 "  [31: 1]   RESERVED_BITS_31_1             = "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EXPORT_MISR                    = " "0 (BYPASS_MISR),1 (MISR_VALUE) "
  tree.end
  tree "MDP_TEST_MISR_CURR_VAL"
   group.long 0x34--0x37 "MDP_TEST_MISR_CURR_VAL (at 0x8001e034)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   VAL                            = "
  tree.end
  tree "MDP_INIT_SST_RD_PTR"
   group.long 0x38--0x3b "MDP_INIT_SST_RD_PTR (at 0x8001e038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_BITS_31_12            = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   INIT_SST_READ_PTR              = "
  tree.end
  tree "MDP_ADDRESS_14"
   group.long 0x38--0x3b "MDP_ADDRESS_14 (at 0x8001e038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_BITS_31_12            = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   INIT_SST_READ_PTR              = "
  tree.end
  tree "MDP_MAX_SST_RD_PTR"
   group.long 0x3c--0x3f "MDP_MAX_SST_RD_PTR (at 0x8001e03c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_BITS31_12             = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MAX_SST_READ_PTR               = "
  tree.end
  tree "MDP_ADDRESS_15"
   group.long 0x3c--0x3f "MDP_ADDRESS_15 (at 0x8001e03c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_BITS31_12             = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   MAX_SST_READ_PTR               = "
  tree.end
  tree "MDP_DEBUG_BUS_VALUE"
   group.long 0x40--0x43 "MDP_DEBUG_BUS_VALUE (at 0x8001e040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DEBUG_BUS_VAL                  = "
  tree.end
tree.end

base ad:0x80004000
tree "MISC_REGS"
  tree "UXMC_PSRAM_CRE_CFG"
   group.long 0x0--0x3 "UXMC_PSRAM_CRE_CFG (at 0x80004000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BCR_ADDR_CTL                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PSRAM_CRE_ENA                  = " "0,1 "
  tree.end
  tree "UXMC_CALIB_CFG"
   group.long 0x4--0x7 "UXMC_CALIB_CFG (at 0x80004004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_EBI2_IO_CLK               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TEST_EBI1_IO_CLK               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CALIB_PGM_DLY_CTL              = "
  tree.end
  tree "UXMC_CALIB_STATUS"
   group.long 0x8--0xb "UXMC_CALIB_STATUS (at 0x80004008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CALIB_RDATA                    = " "0,1,2,3 "
  tree.end
  tree "UXMC_CORE_ID"
   group.long 0xc--0xf "UXMC_CORE_ID (at 0x8000400c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_31_16                 = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   CORE_ID                        = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   MAJOR_REV                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   MINOR_REV                      = "
  tree.end
tree.end

base ad:0x91000000
tree "MMDSP"
  tree "MDSP_RAMA_BASE"
   group.long 0x0--0x3 "MDSP_RAMA_BASE (at 0x91000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RAM_DATA                       = "
  tree.end
  tree "MDSP_RAMB_BASE"
   group.long 0x200000--0x200003 "MDSP_RAMB_BASE (at 0x91200000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RAM_DATA                       = "
  tree.end
  tree "MDSP_RAMC_BASE"
   group.long 0x400000--0x400003 "MDSP_RAMC_BASE (at 0x91400000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RAM_DATA                       = "
  tree.end
  tree "MDSP_RAMI_BASE"
   group.long 0x800000--0x800003 "MDSP_RAMI_BASE (at 0x91800000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RAM_DATA                       = "
  tree.end
  tree "MDSP_CTRL"
   group.long 0xc00000--0xc00003 "MDSP_CTRL (at 0x91c00000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MICRO_DSP_CTRL                 = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RESERVED_BITS3_2               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   QDSP_DECRYPTION_EN             = " "0 (DISABLE_INSTRUCTION_DECRYPTION),1 (WHEN_HIGH_IN_CONJUNCTION_WITH_THE_PORT_REGISTER_BIT_DECRYPTION_CTRL_DECRYPTION_EN_THIS_BIT_ENABLES_INSTRUCTION_DECRYPTION_FOR_MORE_DETAILS_PLEASE_SEE_QDSP4000_INTERNAL_FEATURES) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   FIRMWARE_RESET                 = " "0 (START_FIRMWARE_EXECUTION),1 (DISABLE_AND_RESET_FIRMWARE_EXECUTION) "
  tree.end
  tree "MDSP_UP_IRQ"
   group.long 0xc00004--0xc00007 "MDSP_UP_IRQ (at 0x91c00004)   (shadowed - Use hwio_shadow_ptr->MDSP_UP_IRQ to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DSP_UP_IRQ                     = " "0,1 "
  tree.end
  tree "MDSP_UP_IRQ_VECTOR"
   group.long 0xc00008--0xc0000b "MDSP_UP_IRQ_VECTOR (at 0x91c00008)   (shadowed - Use hwio_shadow_ptr->MDSP_UP_IRQ_VECTOR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   DSP_UP_IRQ_VECTOR              = "
  tree.end
  tree "MDSP_CLK_GATE_CTRL"
   group.long 0xc00010--0xc00013 "MDSP_CLK_GATE_CTRL (at 0x91c00010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   AGU_CLK_OVR_N                  = " "0 (THE_AGU_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (THE_AGU_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   AGUA_OVR_N                     = " "0 (THE_AGUA_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (THE_AGUA_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   AGUB_OVR_N                     = " "0 (THE_AGUB_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (THE_AGUB_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   AGUC_OVR_N                     = " "0 (THE_AGUC_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (THE_AGUC_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   PCLK_OVR_N                     = " "0 (PORT_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (PORT_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   REGFILE_CLK_OVR_N              = " "0 (REGFILE_CLOCK_IS_ON_WHENEVER_ACLK_IS_RUNNING),1 (REGFILE_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   COPRO_CLK_OVR_N                = " "0 (COPROCESSOR_CLOCK_IS_ON_WHENEVER_ACLK_IS_RUNNING),1 (COPROCESSOR_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RESERVED_BIT2                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   XMEMC_CLK_OVR_N                = " "0 (XMEMC_CLOCK_IS_ON_WHENEVER_SCLK_IS_RUNNING),1 (XMEMC_CLOCK_IS_CONTROLLED_BY_DSP_LOGIC) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
  tree.end
  tree "MDSP_CLK_STATUS"
   group.long 0xc00014--0xc00017 "MDSP_CLK_STATUS (at 0x91c00014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   AGU_CLK_OFF                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   AGUA_CLK_OFF                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   AGUB_CLK_OFF                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   AGUC_CLK_OFF                   = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x9--0xc 1 "  [12: 9]   RESERVED_BITS12_9              = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   DMA_CLK_OFF                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   XMEMC_CLK_OFF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RAM_CLK_OFF                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DBG_BUS_CLK_OFF                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   COPRO_CLK_OFF                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REGFILE_SHDW_CLK_OFF           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   REGFILE_CLK_OFF                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PCLK_OFF                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ACLK_OFF                       = " "0,1 "
  tree.end
  tree "MDSP_DBG_CTRL"
   group.long 0xc0001c--0xc0001f "MDSP_DBG_CTRL (at 0x91c0001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DBG_BUS_RATE                   = "
  tree.end
  tree "MDSP_PC_DBG"
   group.long 0xc00020--0xc00023 "MDSP_PC_DBG (at 0x91c00020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x14 1 "  [20: 0]   PC_DBG                         = "
  tree.end
  tree "MDSP_INT_MASK_DBG"
   group.long 0xc00024--0xc00027 "MDSP_INT_MASK_DBG (at 0x91c00024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GLOBAL_DISABLE                 = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   INT_MASK                       = "
  tree.end
  tree "MDSP_INT_MASK2_DBG"
   group.long 0xc00028--0xc0002b "MDSP_INT_MASK2_DBG (at 0x91c00028)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GLOBAL_DISABLE                 = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   INT_MASK2                      = "
  tree.end
  tree "MDSP_MEM_ACC_CTRL"
   group.long 0xc0002c--0xc0002f "MDSP_MEM_ACC_CTRL (at 0x91c0002c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ACC_CTRL_ROM                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ACC_CTRL_RAM                   = "
  tree.end
tree.end

base ad:0x90002000
tree "MOD_ERAM"
  tree "MOD_ERAM_DATA"
   group.long 0x0--0x3 "MOD_ERAM_DATA (at 0x90002000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "MOD_ERAM_DATA_CTL"
   group.long 0x908--0x90b "MOD_ERAM_DATA_CTL (at 0x90002908)   (shadowed - Use hwio_shadow_ptr->MOD_ERAM_DATA_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb "  [   11]   RESERVED_1ST                   = " "0 (NON_1ST_WRITE),1 (1ST_WRITE) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   RESERVED_EN                    = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   DOA_ERAM_SEL                   = " "0 (DO_A_ERAM0),1 (DO_A_ERAM1),2 (DO_A_ERAM2),3 (DO_A_ERAM3) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DOA_ERAM_SEL_OVERRIDE          = " "0 (MDSP_CONTROL),1 (ARM_CONTROL) "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   BYTE_POS                       = " "0 (LSB),1 (2ND_LSB),2 (2ND_MSB),3 (MSB) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   HALF_WORD_POS                  = " "0 (LSB),1 (MSB) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DATA_FORMAT                    = " "0 (WORD),1 (HALF_WORD),2 (BYTE),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ERAM_SEL                       = " "0 (CH1),1 (CH2),2 (CH3),3 (PDCH) "
  tree.end
  tree "MOD_ERAM_RESERVED_BITS"
   group.long 0x910--0x913 "MOD_ERAM_RESERVED_BITS (at 0x90002910)   (shadowed - Use hwio_shadow_ptr->MOD_ERAM_RESERVED_BITS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DATA                           = " "0,1,2,3 "
  tree.end
  tree "MOD_TEST_MEM_MODE"
   group.long 0x914--0x917 "MOD_TEST_MEM_MODE (at 0x90002914)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MEM_MODE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   MODE                           = " "0 (NORMAL_MODE),1 (TEST_MODE) "
  tree.end
  tree "MOD_TEST_MEM_SEL"
   group.long 0x918--0x91b "MOD_TEST_MEM_SEL (at 0x90002918)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                            = "
  tree.end
  tree "MOD_TEST_MEM_ADDR"
   group.long 0x91c--0x91f "MOD_TEST_MEM_ADDR (at 0x9000291c)   (shadowed - Use hwio_shadow_ptr->MOD_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   ADDR                           = "
  tree.end
  tree "MOD_TEST_MEM_DATA"
   group.long 0x920--0x923 "MOD_TEST_MEM_DATA (at 0x90002920) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "MOD_TXCX16_SPARE_READ_REG_0"
   group.long 0x924--0x927 "MOD_TXCX16_SPARE_READ_REG_0 (at 0x90002924) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
  tree "MOD_TXCX16_SPARE_READ_REG_1"
   group.long 0x928--0x92b "MOD_TXCX16_SPARE_READ_REG_1 (at 0x90002928) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SPARE_BITS                     = "
  tree.end
tree.end
tree "MODEM"
base ad:0x90004000
tree "MODEM_CLK"
  tree "MODEM_CLK_HALT"
   group.long 0x0--0x3 "MODEM_CLK_HALT (at 0x90004000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CDMA_CHIPXN_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CDMA_CHIPXN_DIV2_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   CDMA_CHIPXN_DIV4_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RXF_SAMP_CLK_HALT              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1b 1 "  [27:23]   RESERVED_BITS27_23             = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EDGE_CLK_HALT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EDGE_DIV2_CLK_HALT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GSM_CLK_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   FB_ANT0_CLK_HALT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   FB_ANT1_CLK_HALT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   TX_PDM_CLK_HALT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TCXO_PDM_CLK_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MDSP_CLK_HALT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CDMA_SLPFAST_CHIPXN_REF1_HALT  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CDMA_SLPFAST_CHIPXN_REF2_HALT  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SLPFAST_GSM_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   SLPFAST_FEE_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BT_CLK_HALT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MODEM_SBI_CLK_HALT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MODEM_WEB_CLK_HALT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OFFLINE_CLK_HALT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GACC_CLK_HALT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GPS_CHIPX8_CLK_HALT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   F9_CLK_HALT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TX_DAC_CLK_HALT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PC_DAC_CLK_HALT                = " "0,1 "
  tree.end
  tree "MODEM_CLK_HALT_2"
   group.long 0x4--0x7 "MODEM_CLK_HALT_2 (at 0x90004004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPS_SAMP_CLK_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GSM_RXF_SAMP_CLK_HALT          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   EDGE_RESYNC_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   EDGE_RESAMP_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   TXC_DIV4_CLK_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   TXC_CLK_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   IN_N_OUT_CLK_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x14 "  [20:18]   UNUSED_BITS20_18               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   CDXO_Y_CUT_CLK_HALT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CDXO_AT_CUT_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SAMP_FIFO_CLK1_HALT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SAMP_FIFO_CLK0_HALT            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RXF_SAMP_REF_CLK_HALT          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPS_CHIPX32_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GPS_CHIPX16_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   TX_RAM_CLK_HALT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SSRV_OFFLINE_CLK1_HALT         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SSRV_OFFLINE_CLK0_HALT         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYM_BUFF_CLK_HALT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CC_RAM_CLK_HALT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   WCDMA_SLPFAST_CHIPXN_REF_HALT  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WCDMA_CHIPXN_CLK_HALT          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   WCDMA_CHIPXN_DIV2_CLK_HALT     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WCDMA_CHIPXN_DIV4_CLK_HALT     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BT_SBI_CLK_HALT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MDM_CLK_HALT                   = " "0,1 "
  tree.end
  tree "MODEM_CLK_RESET"
   group.long 0x8--0xb "MODEM_CLK_RESET (at 0x90004008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CDMA_CHIPXN_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CDMA_CHIPXN_DIV2_RESET         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   CDMA_CHIPXN_DIV4_RESET         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RXF_SAMP_RESET                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1b 1 "  [27:23]   RESERVED_BITS27_23             = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EDGE_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EDGE_DIV2_RESET                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GSM_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   FB_ANT0_RESET                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   FB_ANT1_RESET                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   TX_PDM_RESET                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TCXO_PDM_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MDSP_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CDMA_SLPFAST_CHIPXN_REF1_RESET = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CDMA_SLPFAST_CHIPXN_REF2_RESET = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SLPFAST_GSM_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   SLPFAST_FEE_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BT_RESET                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MODEM_SBI_RESET                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MODEM_WEB_RESET                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OFFLINE_RESET                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GACC_RESET                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GPS_CHIPX8_RESET               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   F9_RESET                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP_RESET                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BT_SBI_CLK_RESET               = " "0,1 "
  tree.end
  tree "MODEM_CLK_RESET_2"
   group.long 0xc--0xf "MODEM_CLK_RESET_2 (at 0x9000400c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GPS_SAMP_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   GSM_RXF_SAMP_RESET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   EDGE_RESYNC_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   EDGE_RESAMP_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TXC_DIV4_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   TXC_RESET                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   IN_N_OUT_RESET                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RXF_SAMP_REF_RESET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPS_CHIPX32_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GPS_CHIPX16_RESET              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   UNUSED_BITS10_8                = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYM_BUFF_CLK_RESET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CC_RAM_CLK_RESET               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   WCDMA_SLPFAST_CHIPXN_REF_RESET = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WCDMA_CHIPXN_RESET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   WCDMA_CHIPXN_DIV2_RESET        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WCDMA_CHIPXN_DIV4_RESET        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MDM_RESET                      = " "0,1 "
  tree.end
  tree "MODEM_CLK_INV"
   group.long 0x10--0x13 "MODEM_CLK_INV (at 0x90004010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CDMA_CHIPXN_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CDMA_CHIPXN_DIV2_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   CDMA_CHIPXN_DIV4_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RXF_SAMP_CLK_INV               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1b 1 "  [27:23]   RESERVED_BITS27_23             = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EDGE_CLK_INV                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EDGE_DIV2_CLK_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GSM_CLK_INV                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   FB_ANT0_CLK_INV                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   FB_ANT1_CLK_INV                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   TX_PDM_CLK_INV                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TCXO_PDM_CLK_INV               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MDSP_CLK_INV                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   CDMA_SLPFAST_CHIPXN_REF1_INV   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   CDMA_SLPFAST_CHIPXN_REF2_INV   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SLPFAST_GSM_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   SLPFAST_FEE_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BT_CLK_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MODEM_SBI_CLK_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MODEM_WEB_CLK_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OFFLINE_CLK_INV                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GACC_CLK_INV                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GPS_CHIPX8_CLK_INV             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   F9_CLK_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TX_DAC_CLK_INV                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PC_DAC_CLK_INV                 = " "0,1 "
  tree.end
  tree "MODEM_CLK_INV_2"
   group.long 0x14--0x17 "MODEM_CLK_INV_2 (at 0x90004014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPS_SAMP_CLK_INV               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GSM_RXF_SAMP_CLK_INV           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   EDGE_RESYNC_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   EDGE_RESAMP_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   TXC_DIV4_CLK_INV               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   TXC_CLK_INV                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   IN_N_OUT_CLK_INV               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   EXT_SSBI_CLK2_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   EXT_SSBI_CLK1_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   EXT_SSBI_CLK0_INV              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   RESERVED_BITS17_16             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SAMP_FIFO_CLK1_INV             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SAMP_FIFO_CLK0_INV             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RXF_SAMP_REF_CLK_INV           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPS_CHIPX32_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GPS_CHIPX16_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   TX_RAM_CLK_INV                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SSRV_OFFLINE_CLK1_INV          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SSRV_OFFLINE_CLK0_INV          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYM_BUFF_CLK_INV               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CC_RAM_CLK_INV                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   WCDMA_SLPFAST_CHIPXN_REF_INV   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WCDMA_CHIPXN_CLK_INV           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   WCDMA_CHIPXN_DIV2_CLK_INV      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WCDMA_CHIPXN_DIV4_CLK_INV      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BT_SBI_CLK_INV                 = " "0,1 "
  tree.end
  tree "MODEM_RXF_SAMP_REF_CLK_CTL"
   group.long 0x18--0x1b "MODEM_RXF_SAMP_REF_CLK_CTL (at 0x90004018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CLK_DIV                        = " "0 (DIV_1),1 (DIV_2),2 (reserved),3 (DIV_4) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   TEST_CLK_SEL                   = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (TEST_OVERRIDE),2 (reserved),3 (reserved),4 (DCPLL0),5 (DCPLL1),6 (GPLL0),7 (GPLL1) "
  tree.end
  tree "MODEM_IN_N_OUT_CLK_CTL"
   group.long 0x1c--0x1f "MODEM_IN_N_OUT_CLK_CTL (at 0x9000401c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EN                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   RES                            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DIV_N                          = "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAW_CLK_SRC_SEL                = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (GPLL1) "
  tree.end
  tree "MODEM_MF_CHIPXN_CLK_CTL"
   group.long 0x20--0x23 "MODEM_MF_CHIPXN_CLK_CTL (at 0x90004020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   GRP3_CHIPXN_DIV2_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   GRP3_CHIPXN_DIV4_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   GRP2_CHIPXN_DIV2_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   GRP2_CHIPXN_DIV4_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GRP1_CHIPXN_CLK_HALT           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GRP1_CHIPXN_DIV2_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   GRP1_CHIPXN_DIV4_CLK_HALT      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   GRP3_CHIPXN_DIV2_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   GRP3_CHIPXN_DIV4_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GRP2_CHIPXN_DIV2_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GRP2_CHIPXN_DIV4_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GRP1_CHIPXN_CLK_INV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   GRP1_CHIPXN_DIV2_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   GRP1_CHIPXN_DIV4_CLK_INV       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   WCDMA_CHIPXN_PH3_SEL           = " "0 (THE_MUX_OUTPUT_THAT_IS_CONTROLLED_BY_BIT_20_AND_BITS_17_16_OF_MODEM_CHIPXN_CLK_CTL),1 (PHASE_1_OUTPUT_OF_THE_MND_CLOCK),2 (PHASE_3_OUTPUT_OF_THE_MND_CLOCK),3 (MODEM_EXT_CLK1_IN) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   WCDMA_CHIPXN_PH1_SEL           = " "0 (THE_MUX_OUTPUT_THAT_IS_CONTROLLED_BY_BIT_20_AND_BITS_17_16_OF_MODEM_CHIPXN_CLK_CTL),1 (PHASE_1_OUTPUT_OF_THE_MND_CLOCK) "
  tree.end
  tree "MODEM_CHIPXN_CLK_CTL"
   group.long 0x24--0x27 "MODEM_CHIPXN_CLK_CTL (at 0x90004024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a "  [   26]   WCDMA_SEL_MDSP                 = " "0 (ARM),1 (MDSP) "
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   SEL_MDSP                       = " "0 (ARM),1 (MDSP) "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   WCDMA_MN_DUAL_MODE             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   WCDMA_MN_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   WCDMA_MN_RES                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   WCDMA_MN_OUT_SEL               = " "0 (INTEGER_DIVIDER),1 (MN_COUNTER) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   WCDMA_TEST_CLK_SEL             = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   WCDMA_CLK_SRC_DIV              = " "0 (DIV_1),1 (DIV_2),2 (DIV_5),3 (DIV_10) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   WCDMA_CLK_SRC_SEL              = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (TEST_OVERRIDE) "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED15_19                  = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CDMA_MN_DUAL_MODE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CDMA_MN_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CDMA_MN_RES                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   CDMA_MN_OUT_SEL                = " "0 (INTEGER_DIVIDER),1 (MN_COUNTER) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   CDMA_TEST_CLK_SEL              = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CDMA_CLK_SRC_DIV               = " "0 (DIV_1),1 (DIV_2),2 (DIV_5),3 (DIV_10) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CDMA_CLK_SRC_SEL               = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (TEST_OVERRIDE) "
  tree.end
  tree "MODEM_OFFLINE_MNCNTR_M"
   group.long 0x28--0x2b "MODEM_OFFLINE_MNCNTR_M (at 0x90004028)   (shadowed - Use hwio_shadow_ptr->MODEM_OFFLINE_MNCNTR_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MN_M                           = "
  tree.end
  tree "MODEM_OFFLINE_MNCNTR_NOT_2D"
   group.long 0x2c--0x2f "MODEM_OFFLINE_MNCNTR_NOT_2D (at 0x9000402c)   (shadowed - Use hwio_shadow_ptr->MODEM_OFFLINE_MNCNTR_NOT_2D to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_OFFLINE_MNCNTR_NOT_N_M"
   group.long 0x30--0x33 "MODEM_OFFLINE_MNCNTR_NOT_N_M (at 0x90004030)   (shadowed - Use hwio_shadow_ptr->MODEM_OFFLINE_MNCNTR_NOT_N_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_OFFLINE_CLK_CTL"
   group.long 0x34--0x37 "MODEM_OFFLINE_CLK_CTL (at 0x90004034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MN_DUAL_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MN_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MN_RES                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   MN_OUT_SEL                     = " "0 (INTEGER_DIVIDER),1 (MN_COUNTER) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   TEST_CLK_SEL                   = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CLK_SRC_DIV                    = " "0 (DIV_1),1 (DIV_2),2 (DIV_3),3 (DIV_4) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (TEST_OVERRIDE) "
  tree.end
  tree "MODEM_GACC_MNCNTR_M"
   group.long 0x38--0x3b "MODEM_GACC_MNCNTR_M (at 0x90004038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MN_M                           = "
  tree.end
  tree "MODEM_GACC_MNCNTR_NOT_2D"
   group.long 0x3c--0x3f "MODEM_GACC_MNCNTR_NOT_2D (at 0x9000403c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_GACC_MNCNTR_NOT_N_M"
   group.long 0x40--0x43 "MODEM_GACC_MNCNTR_NOT_N_M (at 0x90004040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_GACC_CLK_CTL"
   group.long 0x44--0x47 "MODEM_GACC_CLK_CTL (at 0x90004044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MN_DUAL_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MN_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MN_RES                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   MN_OUT_SEL                     = " "0 (INTEGER_DIVIDER),1 (MN_COUNTER) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   TEST_CLK_SEL                   = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CLK_SRC_DIV                    = " "0 (DIV_1),1 (DIV_3) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (TEST_OVERRIDE) "
  tree.end
  tree "MODEM_GPS_CLK_CTL"
   group.long 0x48--0x4b "MODEM_GPS_CLK_CTL (at 0x90004048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   MN_UPDATE_SEL                  = " "0 (USE_THE_UPDATE_STROBE_FROM_ARM),1 (USE_THE_UPDATE_STROBE_FROM_MDSP),2 (USE_GPS_BC_IRQ_FROM_GPS_BASEBAND_PROCESSOR),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   SEL_MDSP                       = " "0 (USE_THE_PARAMETERS_FROM_ARM),1 (USE_THE_PARAMETERS_FROM_MDSP) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   GPS_EXT_TEST_MODE              = " "0 (NORMAL_MODE),1 (EXTERNAL_TEST_MODE) "
    textline ""
    hexmask.long.byte 0x0 0xb--0x10 1 "  [16:11]   RESERVED_BITS16_11             = "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GPS_SAMP_CLK_SEL               = " "0 (GPS_CHIPX32_CLK),1 (GPS_CHIPX16_CLK),2 (GPS_CHIPX8_CLK),3 (TCXO_CLK),4 (ANT0_SAMPLE_CLK_FB),5 (ANT1_SAMPLE_CLK_FB),6 (MODEM_EXT_CLK1_IN),7 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MN_DUAL_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MN_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MN_RES                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   MN_OUT_SEL                     = " "0 (RAW_SOURCE),1 (MN_COUNTER) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BITS3                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (MODEM_EXT_CLK1_IN),2 (MODEM_EXT_CLK2_IN),3 (GND),4 (DCPLL0),5 (DCPLL1),6 (GPLL0),7 (GPLL1) "
  tree.end
  tree "MODEM_GPS_MNCNTR_M"
   group.long 0x4c--0x4f "MODEM_GPS_MNCNTR_M (at 0x9000404c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   MN_M                           = "
  tree.end
  tree "MODEM_GPS_MNCNTR_NOT_2D"
   group.long 0x50--0x53 "MODEM_GPS_MNCNTR_NOT_2D (at 0x90004050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_GPS_MNCNTR_NOT_N_M"
   group.long 0x54--0x57 "MODEM_GPS_MNCNTR_NOT_N_M (at 0x90004054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_F9_CLK_CTL"
   group.long 0x58--0x5b "MODEM_F9_CLK_CTL (at 0x90004058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   F9_CLK_DIV_SEL                 = " "0 (TCXO_DIV_1),1 (TCXO_DIV_2),2 (TCXO_DIV_3),3 (TCXO_DIV_4) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   TEST_CLK_SEL                   = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (TEST_OVERRIDE) "
  tree.end
  tree "MODEM_EDGE_CLK_CTL"
   group.long 0x5c--0x5f "MODEM_EDGE_CLK_CTL (at 0x9000405c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SWC_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SWC_RES                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   GSM_ONLY                       = " "0 (EDGE_AND_GSM_CLOCKS),1 (GSM_ONLY) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MN_DUAL_MODE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MN_EN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MN_RES                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   MN_OUT_SEL                     = " "0 (RAW_SOURCE),1 (MN_OR_CYCLE_SWALLOW_COUNTER) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (GPLL0),2 (GPLL1),3 (TCXO_X3),4 (MODEM_EXT_CLK1_IN),5 (MODEM_EXT_CLK2_IN),6 (reserved),7 (GPLL1) "
  tree.end
  tree "MODEM_EDGE_MNCNTR_M"
   group.long 0x60--0x63 "MODEM_EDGE_MNCNTR_M (at 0x90004060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   MN_M                           = "
  tree.end
  tree "MODEM_EDGE_MNCNTR_NOT_2D"
   group.long 0x64--0x67 "MODEM_EDGE_MNCNTR_NOT_2D (at 0x90004064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_EDGE_MNCNTR_NOT_N_M"
   group.long 0x68--0x6b "MODEM_EDGE_MNCNTR_NOT_N_M (at 0x90004068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_WCDMA_CHIPXN_MNCTNR_UPDATE"
   group.long 0x6c--0x6f "MODEM_WCDMA_CHIPXN_MNCTNR_UPDATE (at 0x9000406c) "
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_WEB_CLK_CTL"
   group.long 0x8c--0x8f "MODEM_WEB_CLK_CTL (at 0x9000408c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   WEB_CLK_DIV_SEL                = " "0 (TCXO_DIV_1),1 (TCXO_DIV_2),2 (TCXO_DIV_3),3 (TCXO_DIV_4) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TEST_CLK_SEL                   = " "0 (MODEM_EXT_CLK1_IN),1 (MODEM_EXT_CLK2_IN) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SRC_SEL                    = " "0 (TCXO),1 (SLEEP_XTAL),2 (TEST_OVERRIDE),3 (reserved) "
  tree.end
  tree "MODEM_CHIPXN_CLK_MISC_CTL"
   group.long 0x90--0x93 "MODEM_CHIPXN_CLK_MISC_CTL (at 0x90004090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1c "  [28:27]   WCDMA_RX_SAMPLE_RAW_SEL        = " "0 (TCXO_CLK),1 (ANT0_SAMPLE_CLK_FB),2 (reserved),3 (MODEM_EXT_CLK1_IN) "
    textline ""
    bitfld.long 0x0 0x19--0x1a "  [26:25]   RESERVED_BITS26_25             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   WCDMA_CHIPXN_SRC_SEL           = " "0 (WCDMA_CHIPXN_REV_DIV1),1 (RX_SAMPLE_CLK_RAW) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   NOT_USED                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   GPS_CHIPXN_RESET               = " "0 (OUT_OF_RESET),1 (RESETS_ALL_GPS_CHIPNX_CLOCKS) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   ANT1_SAMP_CLK_INV              = " "0 (SOURCE_NOT_INVERTED),1 (SOURCE_INVERTED) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   ANT0_SAMP_CLK_INV              = " "0 (SOURCE_NOT_INVERTED),1 (SOURCE_INVERTED) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   CDMA_CHIPXN_SRC_SEL            = " "0 (CDMA_CHIPXN_REV_DIV1),1 (RX_SAMPLE_CLK_RAW) "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   CDMA_RX_SAMPLE_RAW_SEL         = " "0 (TCXO_CLK),1 (ANT0_SAMPLE_CLK_FB),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0xe--0x10 "  [16:14]   SLPFAST_FEE_SRC_SEL            = " "0 (TCXO),1 (MODEM_EXT_CLK1_IN),2 (MODEM_EXT_CLK2_IN),3 (reserved),4 (USE_CDMA_CHIPX16_CLK),5 (USE_CDMA_CHIPX8_CLK),6 (USE_UMTS_CHIPX16_CLK),7 (USE_UMTS_CHIPX8_CLK) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BITS13_12             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   CDMA_CHIPXN_RESET              = " "0 (OUT_OF_RESET),1 (RESETS_CDMA_CHIPXN_CLOCKS) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   WCDMA_CHIPXN_RESET             = " "0 (OUT_OF_RESET),1 (RESETS_CDMA_CHIPXN_CLOCKS) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   RESERVED_BITS9_8               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RESERVED_BITS5_0               = "
  tree.end
  tree "MODEM_CLK_MISC_CTL"
   group.long 0x94--0x97 "MODEM_CLK_MISC_CTL (at 0x90004094) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   WCDMA_CHIPXN_CLK_DIV           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   ANT1_CLK_DSP_CTL_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   ANT0_CLK_DSP_CTL_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   CDMA_CHIPXN_CLK_DIV            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x1a "  [26:25]   BT_SBI_CLK_DIV                 = " "0 (DIV1),1 (DIV2),2 (DIV3),3 (DIV4) "
    textline ""
    bitfld.long 0x0 0x17--0x18 "  [24:23]   BT_SBI_CLK_SRC_SEL             = " "0 (TCXO),1 (TCXOZ),2 (MODEM_EXT_CLK0_IN),3 (MODEM_EXT_CLK1_IN) "
    textline ""
    bitfld.long 0x0 0x15--0x16 "  [22:21]   BT_CLK_SRC_SEL                 = " "0 (BT_CLK_IN),1 (reserved),2 (MODEM_EXT_CLK0_IN),3 (MODEM_EXT_CLK1_IN) "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   MDSP_HM_CLK_OVR_N              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   MDSP_CLK_1X_MODE               = " "0 (FREQ_2X_MODE),1 (FREQ_1X_MODE) "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   MDSP_DMA_CLK_OVR_N             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   ANT_SAMP_CHIPXN_DIV_SEL        = " "0 (CHIPXN_DIV1),1 (CHIPXN_DIV2),2 (CHIPXN_DIV3),3 (CHIPXN_DIV4) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   MDSP_CLK_HALT_TIMER_VAL        = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   TX_DAC_CHIPXN_SEL              = " "0 (reserved),1 (CDMA_CHIPXN_DIV2),2 (WCDMA_CHIPXN_DIV1),3 (WCDMA_CHIPXN_DIV2) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   SBI_CLK_SRC_SEL                = " "0 (TCXO),1 (PLL_DIV_N),2 (MODEM_EXT_CLK0_IN),3 (MODEM_EXT_CLK1_IN) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   GPS_FB_ANT_SRC_SEL             = " "0 (ANT0_SAMPLE_CLK_FB),1 (ANT1_SAMPLE_CLK_FB) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   GPS_FB_CLK_SEL                 = " "0 (USE_INTERNAL_CLK),1 (USE_FB_CLK) "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TX_PDM_CLK_SRC_SEL             = " "0 (TCXO),1 (CDMA_CHIPXN_DIV1),2 (CDMA_CHIPXN_DIV2),3 (CDMA_CHIPXN_DIV4),4 (reserved),5 (WCDMA_CHIPXN_DIV1),6 (WCDMA_CHIPXN_DIV2),7 (MODEM_EXT_CLK0_IN) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TCXO_PDM_CLK_SRC_SEL           = " "0 (TCXO),1 (CDMA_CHIPXN_DIV1),2 (CDMA_CHIPXN_DIV2),3 (CDMA_CHIPXN_DIV4),4 (reserved),5 (WCDMA_CHIPXN_DIV1),6 (WCDMA_CHIPXN_DIV2),7 (MODEM_EXT_CLK0_IN) "
  tree.end
  tree "MODEM_CLK_MISC_CTL_2"
   group.long 0x98--0x9b "MODEM_CLK_MISC_CTL_2 (at 0x90004098) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x12--0x14 "  [20:18]   GSM_RXF_SAMP_CLK_SEL           = " "0 (TCXO_CLK),1 (ANT0_SAMPLE_CLK_FB),2 (ANT1_SAMPLE_CLK_FB),3 (MODEM_EXT_CLK1_IN),4 (MODEM_EXT_CLK2_IN),5 (EDGE_DIV2_CLK),6 (GSM_CLK),7 (MODEM_EXT_CLK0_IN) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   TXC_SEL_EDGE_CLK               = " "0 (WCDMA_CHIPXN),1 (EDGE_CLK) "
    textline ""
    bitfld.long 0x0 0xf--0x10 "  [16:15]   SAMPLE_FIFO_CLK_SRC_SEL1       = " "0 (CDMA_CHIPXN_DIV2),1 (WCDMA_CHIPXN_DIV2),2 (GPS_CHIPX16_CLK),3 (GPS_CHIPX32_CLK) "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   SAMPLE_FIFO_CLK_SRC_SEL0       = " "0 (CDMA_CHIPXN_DIV2),1 (WCDMA_CHIPXN_DIV2),2 (GPS_CHIPX16_CLK),3 (GPS_CHIPX32_CLK) "
    textline ""
    hexmask.long.byte 0x0 0x9--0xc 1 "  [12: 9]   ANT1_SAMP_CLK_SRC_SEL          = "
    textline ""
    hexmask.long.byte 0x0 0x5--0x8 1 "  [ 8: 5]   ANT0_SAMP_CLK_SRC_SEL          = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_RAM_CLK_SRC_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CC_RAM_CLK_SRC_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SYM_BUFF_CLK_SRC_SEL           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SSRV_OFFLINE_CLK1_SRC_SEL      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SSRV_OFFLINE_CLK0_SRC_SEL      = " "0,1 "
  tree.end
  tree "MODEM_CLK_MDSP_FS_CTL"
   group.long 0x9c--0x9f "MODEM_CLK_MDSP_FS_CTL (at 0x9000409c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   FS_SLEEP                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   FS_WAKE                        = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HM_CLK_UP_FS_ON                = " "0,1 "
  tree.end
  tree "MODEM_CLK_STATUS_RD"
   group.long 0xa0--0xa3 "MODEM_CLK_STATUS_RD (at 0x900040a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   CDMA_CHIPXN_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CDMA_CHIPXN_DIV2_CLK_OFF       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   CDMA_CHIPXN_DIV4_CLK_OFF       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RXF_SAMP_CLK_OFF               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x17--0x1b 1 "  [27:23]   RESERVED_BITS27_23             = "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EDGE_CLK_OFF                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   EDGE_CLK_DIV2_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   GSM_CLK_OFF                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   FB_ANT0_CLK_OFF                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   FB_ANT1_CLK_OFF                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   TX_PDM_CLK_OFF                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TCXO_PDM_CLK_OFF               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MDSP_CLK_OFF                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SLPFAST_CDMA_CHIPXN_REF1_OFF   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SLPFAST_CDMA_CHIPXN_REF2_OFF   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SLPFAST_GSM_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   SLPFAST_FEE_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   BT_CLK_OFF                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MODEM_SBI_CLK_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MODEM_WEB_CLK_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OFFLINE_CLK_OFF                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GACC_CLK_OFF                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GPS_CHIPX8_CLK_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   F9_CLK_OFF                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TX_DAC_CLK_OFF                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PC_DAC_CLK_OFF                 = " "0,1 "
  tree.end
  tree "MODEM_CLK_STATUS_RD_2"
   group.long 0xa4--0xa7 "MODEM_CLK_STATUS_RD_2 (at 0x900040a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   GPS_SAMP_CLK_OFF               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   GSM_RXF_SAMP_CLK_OFF           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   EDGE_RESYNC_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   EDGE_RESAMP_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   TXC_DIV4_CLK_OFF               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   TXC_CLK_OFF                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   IN_N_OUT_CLK_OFF               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   EXT_SSBI_CLK2_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   EXT_SSBI_CLK1_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   EXT_SSBI_CLK0_OFF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   CDXO_Y_CUT_CLK_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CDXO_AT_CUT_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   SAMP_FIFO_CLK1_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   SAMP_FIFO_CLK0_OFF             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RXF_SAMP_REF_CLK_OFF           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   GPS_CHIPX32_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   GPS_CHIPX16_CLK_OFF            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   TX_RAM_CLK_OFF                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SSRV_OFFLINE_CLK1_OFF          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SSRV_OFFLINE_CLK0_OFF          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SYM_BUFF_CLK_OFF               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CC_RAM_CLK_OFF                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   WCDMA_SLPFAST_CHIPXN_REF_CLK_OFF = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   WCDMA_CHIPXN_CLK_OFF           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   WCDMA_CHIPXN_DIV2_CLK_OFF      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WCDMA_CHIPXN_DIV4_CLK_OFF      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BT_SBI_CLK_OFF                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MDM_CLK_OFF                    = " "0,1 "
  tree.end
  tree "MODEM_CLK_TEST"
   group.long 0xa8--0xab "MODEM_CLK_TEST (at 0x900040a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   DBG_CLK_OUT_SEL                = "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DBG_CLK_INV                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   CLK_TEST_EN                    = " "0 (DISABLED),1 (BITS_15_0_ENABLED),2 (BITS_31_16_ENABLED),3 (BITS_31_0_ENABLED) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_TEST_SEL                   = " "0 (DBG_BUS0_DBG_BUS1),1 (DBG_BUS1_DBG_BUS0),2 (DBG_BUS2_DBG_BUS3),3 (DBG_BUS3_DBG_BUS2),4 (DBG_BUS2_DBG_BUS4),5 (reserved),6 (DBG_BUS3_DBG_BUS4),7 (CM_RXF_SAMP_REF_CLK) "
  tree.end
  tree "MODEM_CLK_TEST_2"
   group.long 0xac--0xaf "MODEM_CLK_TEST_2 (at 0x900040ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0xb 1 "  [11: 6]   DBG2_CLK_OUT_SEL               = "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DBG2_CLK_INV                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   CLK_TEST_EN                    = " "0 (DISABLED),1 (BITS_15_0_ENABLED),2 (BITS_31_16_ENABLED),3 (BITS_31_0_ENABLED) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_TEST_SEL                   = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MODEM_CDMA_CHIPXN_MNCNTR_M"
   group.long 0xb0--0xb3 "MODEM_CDMA_CHIPXN_MNCNTR_M (at 0x900040b0)   (shadowed - Use hwio_shadow_ptr->MODEM_CDMA_CHIPXN_MNCNTR_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   MN_M                           = "
  tree.end
  tree "MODEM_CDMA_CHIPXN_MNCNTR_NOT_2D"
   group.long 0xb4--0xb7 "MODEM_CDMA_CHIPXN_MNCNTR_NOT_2D (at 0x900040b4)   (shadowed - Use hwio_shadow_ptr->MODEM_CDMA_CHIPXN_MNCNTR_NOT_2D to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_CDMA_CHIPXN_MNCNTR_NOT_N_M"
   group.long 0xb8--0xbb "MODEM_CDMA_CHIPXN_MNCNTR_NOT_N_M (at 0x900040b8)   (shadowed - Use hwio_shadow_ptr->MODEM_CDMA_CHIPXN_MNCNTR_NOT_N_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_CDMA_CHIPXN_MNCTNR_UPDATE"
   group.long 0xbc--0xbf "MODEM_CDMA_CHIPXN_MNCTNR_UPDATE (at 0x900040bc)   (shadowed - Use hwio_shadow_ptr->MODEM_CDMA_CHIPXN_MNCTNR_UPDATE to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_WCDMA_CHIPXN_MNCNTR_M"
   group.long 0xc0--0xc3 "MODEM_WCDMA_CHIPXN_MNCNTR_M (at 0x900040c0)   (shadowed - Use hwio_shadow_ptr->MODEM_WCDMA_CHIPXN_MNCNTR_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   MN_M                           = "
  tree.end
  tree "MODEM_WCDMA_CHIPXN_MNCNTR_NOT_2D"
   group.long 0xc4--0xc7 "MODEM_WCDMA_CHIPXN_MNCNTR_NOT_2D (at 0x900040c4)   (shadowed - Use hwio_shadow_ptr->MODEM_WCDMA_CHIPXN_MNCNTR_NOT_2D to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_2D                      = "
  tree.end
  tree "MODEM_WCDMA_CHIPXN_MNCNTR_NOT_N_M"
   group.long 0xc8--0xcb "MODEM_WCDMA_CHIPXN_MNCNTR_NOT_N_M (at 0x900040c8)   (shadowed - Use hwio_shadow_ptr->MODEM_WCDMA_CHIPXN_MNCNTR_NOT_N_M to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   MN_NOT_N_MINUS_M               = "
  tree.end
  tree "MODEM_GPS_MNCNTR_UPDATE"
   group.long 0xcc--0xcf "MODEM_GPS_MNCNTR_UPDATE (at 0x900040cc)   (shadowed - Use hwio_shadow_ptr->MODEM_GPS_MNCNTR_UPDATE to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "MDSP_MNCNTR_MD"
   group.long 0xd0--0xd3 "MDSP_MNCNTR_MD (at 0x900040d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   MDSP_MN_M                      = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MDSP_MN_NOT_2D                 = "
  tree.end
  tree "MDSP_MNCNTR_NS"
   group.long 0xd4--0xd7 "MDSP_MNCNTR_NS (at 0x900040d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   MDSP_TRIGGER_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x18 "  [24:23]   NOT_USED                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   MDSP_REF_SRC_SEL               = " "0 (TCXO),1 (reserved),2 (reserved),3 (reserved),4 (reserved),5 (EXT_CLK0),6 (EXT_CLK1),7 (SLEEP_XTAL) "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   MDSP_MN_PREDIV_SEL             = " "0 (DIVIDE_BY_1),1 (DIVIDE_BY_2),2 (DIVIDE_BY_4),3 (DIVIDE_BY_8) "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   MDSP_MN_DUAL_MODE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10 "  [   16]   MDSP_MN_OUT_SEL                = " "0 (RAW_SOURCE),1 (MN_COUNTER) "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MDSP_MN_NOT_N_MINUS_M          = "
  tree.end
  tree "MDSP_ACTIVE_MD_RD"
   group.long 0xd8--0xdb "MDSP_ACTIVE_MD_RD (at 0x900040d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   MDSP_ACTIVE_M                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   MDSP_ACTIVE_NOT_2D             = "
  tree.end
  tree "MDSP_ACTIVE_NS_RD"
   group.long 0xdc--0xdf "MDSP_ACTIVE_NS_RD (at 0x900040dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xf--0x1e 1 "  [30:15]   MDSP_ACTIVE_NOT_N_MINUS_M      = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MDSP_SWITCH_IN_PROGRESS        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MDSP_ACTIVE_LAST_TRIGGER       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MDSP_ACTIVE_OUT_SEL            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MDSP_ACTIVE_DUAL_MODE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MDSP_ACTIVE_PREDIV_SEL         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MDSP_ACTIVE_SRC_SEL            = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MDSP_CLK_SWITCH"
   group.long 0xe0--0xe3 "MDSP_CLK_SWITCH (at 0x900040e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                           = " "0,1 "
  tree.end
  tree "MODEM_CLK_DYN_SW_BYPASS"
   group.long 0xe4--0xe7 "MODEM_CLK_DYN_SW_BYPASS (at 0x900040e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BYPASS                         = " "0,1 "
  tree.end
  tree "MODEM_CLK_DYN_SW_SPARE_READ_REG0"
   group.long 0xe8--0xeb "MODEM_CLK_DYN_SW_SPARE_READ_REG0 (at 0x900040e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WRITE_VAL                      = "
  tree.end
  tree "MODEM_CDXO_CTL"
   group.long 0xec--0xef "MODEM_CDXO_CTL (at 0x900040ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   Y_CUT_CLK_SEL                  = " "0 (TCXO),1 (MODEM_EXT_CLK1_IN),2 (MODEM_EXT_CLK2_IN),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   AT_CUT_CLK_SEL                 = " "0 (TCXO),1 (DCPLL0),2 (DCPLL1),3 (MODEM_EXT_CLK1_IN),4 (MODEM_EXT_CLK2_IN),5 (reserved),6 (reserved),7 (SLEEP_XTAL) "
  tree.end
  tree "MODEM_CDXO_Y_CUT_CNTR_CTL"
   group.long 0xf0--0xf3 "MODEM_CDXO_Y_CUT_CNTR_CTL (at 0x900040f0)   (shadowed - Use hwio_shadow_ptr->MODEM_CDXO_Y_CUT_CNTR_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   START_CMD                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   RESERVED_BITS15_12             = "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   TERMINAL_COUNT                 = "
  tree.end
  tree "MODEM_CDXO_AT_CUT_CNTR"
   group.long 0xf4--0xf7 "MODEM_CDXO_AT_CUT_CNTR (at 0x900040f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   MEASURE_IN_PROGRESS            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   RESERVED_BITS30_28             = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   CNTR                           = "
  tree.end
  tree "MODEM_CLK_SSBI_CLK_CTL"
   group.long 0xf8--0xfb "MODEM_CLK_SSBI_CLK_CTL (at 0x900040f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EN                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RES                            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DIV_N                          = "
  tree.end
  tree "MODEM_EDGE_SWC_CNT"
   group.long 0xfc--0xff "MODEM_EDGE_SWC_CNT (at 0x900040fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CNT                            = "
  tree.end
tree.end

base ad:0x90003900
tree "MODEM_QMEMBIST"
  tree "MODEM_QMEMBIST_CLK_ENA"
   group.long 0x0--0x3 "MODEM_QMEMBIST_CLK_ENA (at 0x90003900) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_ENA                        = " "0,1 "
  tree.end
  tree "MODEM_QMEMBIST_IO_CFG"
   group.long 0x4--0x7 "MODEM_QMEMBIST_IO_CFG (at 0x90003904) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BIST_FAIL_SET_SEL              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BIST_FA_DATA_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BIST_FAIL_EN                   = " "0,1 "
  tree.end
  tree "MODEM_QMEMBIST_RESET"
   group.long 0x8--0xb "MODEM_QMEMBIST_RESET (at 0x90003908) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SW_RESET                       = " "0,1 "
  tree.end
  tree "MODEM_QMEMBIST_FA_SEQUENCER_SEL"
   group.long 0xc--0xf "MODEM_QMEMBIST_FA_SEQUENCER_SEL (at 0x9000390c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FA_SEQUENCER_SEL               = "
  tree.end
  tree "MODEM_QMEMBIST_EMBEDDED_ALG_CFG"
   group.long 0x10--0x13 "MODEM_QMEMBIST_EMBEDDED_ALG_CFG (at 0x90003910) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   ALGORITHM_SEL_MAP              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   REPLACE_RIPPLE_MODE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RIPPLE_ROW                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   REPLACE_PATTERNS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INVERT_BITS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   INVERT_ROWS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_COLUMNS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   OPTIMIZE_BLANKET_MARCH         = " "0 (REGULAR_BLANKET_MARCH),1 (OPTIMIZED_BLANKET_MARCH) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAUSE                          = " "0,1 "
  tree.end
  tree "MODEM_QMEMBIST_USR_CMD_DESTINATION"
   group.long 0x14--0x17 "MODEM_QMEMBIST_USR_CMD_DESTINATION (at 0x90003914) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ID                         = "
  tree.end
  tree "MODEM_QMEMBIST_USR_CMD_CFG"
   group.long 0x18--0x1b "MODEM_QMEMBIST_USR_CMD_CFG (at 0x90003918) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   SEQUENCER_COMMAND              = "
  tree.end
  tree "MODEM_QMEMBIST_TEST_TRIGGER"
   group.long 0x1c--0x1f "MODEM_QMEMBIST_TEST_TRIGGER (at 0x9000391c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   START_USR_CMD                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CONT_EMBEDDED_ALG              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_EMBEDDED_ALG             = " "0,1 "
  tree.end
  tree "MODEM_QMEMBIST_TEST_STATUS"
   group.long 0x20--0x23 "MODEM_QMEMBIST_TEST_STATUS (at 0x90003920)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAUSED                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DONE                           = " "0,1 "
  tree.end
 tree "QMEMBIST_TESTEDm"
  tree "MODEM_QMEMBIST_TESTED0"
   group.long 0x24--0x27 "MODEM_QMEMBIST_TESTED0 (at 0x90003924)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "MODEM_QMEMBIST_TESTED1"
   group.long 0x28--0x2b "MODEM_QMEMBIST_TESTED1 (at 0x90003928)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "MODEM_QMEMBIST_TESTED2"
   group.long 0x2c--0x2f "MODEM_QMEMBIST_TESTED2 (at 0x9000392c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "MODEM_QMEMBIST_TESTED3"
   group.long 0x30--0x33 "MODEM_QMEMBIST_TESTED3 (at 0x90003930)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
 tree.end
 tree "QMEMBIST_FAILEDm"
  tree "MODEM_QMEMBIST_FAILED0"
   group.long 0x34--0x37 "MODEM_QMEMBIST_FAILED0 (at 0x90003934)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "MODEM_QMEMBIST_FAILED1"
   group.long 0x38--0x3b "MODEM_QMEMBIST_FAILED1 (at 0x90003938)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "MODEM_QMEMBIST_FAILED2"
   group.long 0x3c--0x3f "MODEM_QMEMBIST_FAILED2 (at 0x9000393c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "MODEM_QMEMBIST_FAILED3"
   group.long 0x40--0x43 "MODEM_QMEMBIST_FAILED3 (at 0x90003940)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
 tree.end
  tree "MODEM_QMEMBIST_RAM_FAIL_MAP"
   group.long 0x44--0x47 "MODEM_QMEMBIST_RAM_FAIL_MAP (at 0x90003944)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RAM_FAILED                     = "
  tree.end
 tree "QMEMBIST_CLKOFFm"
  tree "MODEM_QMEMBIST_CLKOFF0"
   group.long 0x48--0x4b "MODEM_QMEMBIST_CLKOFF0 (at 0x90003948) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF1"
   group.long 0x4c--0x4f "QMEMBIST_CLKOFF1 (at 0x9000394c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF2"
   group.long 0x50--0x53 "QMEMBIST_CLKOFF2 (at 0x90003950) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF3"
   group.long 0x54--0x57 "QMEMBIST_CLKOFF3 (at 0x90003954) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
 tree.end
tree.end

base ad:0x90004500
tree "MODEM_SBI"
 tree "MODEM_SBIc_CLK_EN"
  tree "MODEM_SBI0_CLK_EN"
   group.long 0x0--0x3 "MODEM_SBI0_CLK_EN (at 0x90004500)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_CLK_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN                         = " "0,1 "
  tree.end
  tree "MODEM_SBI1_CLK_EN"
   group.long 0x40--0x43 "MODEM_SBI1_CLK_EN (at 0x90004540)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_CLK_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_CGC_HW_EN"
  tree "MODEM_SBI0_CGC_HW_EN"
   group.long 0x4--0x7 "MODEM_SBI0_CGC_HW_EN (at 0x90004504)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_CGC_HW_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CGC_HW_EN                      = " "0,1 "
  tree.end
  tree "MODEM_SBI1_CGC_HW_EN"
   group.long 0x44--0x47 "MODEM_SBI1_CGC_HW_EN (at 0x90004544)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_CGC_HW_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CGC_HW_EN                      = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_CLK_CTL"
  tree "MODEM_SBI0_CLK_CTL"
   group.long 0x8--0xb "MODEM_SBI0_CLK_CTL (at 0x90004508)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MICRO_RESET                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CNT_EN                         = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CLKCTL                         = "
  tree.end
  tree "MODEM_SBI1_CLK_CTL"
   group.long 0x48--0x4b "MODEM_SBI1_CLK_CTL (at 0x90004548)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MICRO_RESET                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CNT_EN                         = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CLKCTL                         = "
  tree.end
 tree.end
 tree "MODEM_SBIc_CTL"
  tree "MODEM_SBI0_CTL"
   group.long 0xc--0xf "MODEM_SBI0_CTL (at 0x9000450c)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   HW_REQ3_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HW_REQ3_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   HW_REQ2_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HW_REQ2_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   HW_REQ1_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HW_REQ1_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   I2C_I3Q_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MSM_SBI_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   OVR_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DIAG_MODE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_WORD                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   I3Q_MODE                       = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLAVE_ID                       = "
  tree.end
  tree "MODEM_SBI1_CTL"
   group.long 0x4c--0x4f "MODEM_SBI1_CTL (at 0x9000454c)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   HW_REQ3_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   HW_REQ3_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   HW_REQ2_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   HW_REQ2_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   HW_REQ1_PRIORITY               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   HW_REQ1_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   I2C_I3Q_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MSM_SBI_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   OVR_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DIAG_MODE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_WORD                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   I3Q_MODE                       = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLAVE_ID                       = "
  tree.end
 tree.end
 tree "MODEM_SBIc_BYPASS_WR"
  tree "MODEM_SBI0_BYPASS_WR"
   group.long 0x10--0x13 "MODEM_SBI0_BYPASS_WR (at 0x90004510)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_BYPASS_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   OVR_SBCK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_SBST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_SBDT                       = " "0,1 "
  tree.end
  tree "MODEM_SBI1_BYPASS_WR"
   group.long 0x50--0x53 "MODEM_SBI1_BYPASS_WR (at 0x90004550) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   OVR_SBCK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_SBST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_SBDT                       = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_WR"
  tree "MODEM_SBI0_WR"
   group.long 0x14--0x17 "MODEM_SBI0_WR (at 0x90004514) "
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_SBI1_WR"
   group.long 0x54--0x57 "MODEM_SBI1_WR (at 0x90004554)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_WR to read/write)"
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "MODEM_SBIc_START_CTL"
  tree "MODEM_SBI0_START_CTL"
   group.long 0x18--0x1b "MODEM_SBI0_START_CTL (at 0x90004518)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_START_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_FLAG                     = " "0,1 "
  tree.end
  tree "MODEM_SBI1_START_CTL"
   group.long 0x58--0x5b "MODEM_SBI1_START_CTL (at 0x90004558)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_START_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_FLAG                     = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_SECOND_IDCODE"
  tree "MODEM_SBI0_SECOND_IDCODE"
   group.long 0x1c--0x1f "MODEM_SBI0_SECOND_IDCODE (at 0x9000451c)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI0_SECOND_IDCODE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_SECOND_IDCODE              = "
  tree.end
  tree "MODEM_SBI1_SECOND_IDCODE"
   group.long 0x5c--0x5f "MODEM_SBI1_SECOND_IDCODE (at 0x9000455c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_SECOND_IDCODE              = "
  tree.end
 tree.end
 tree "MODEM_SBIc_STATUS"
  tree "MODEM_SBI0_STATUS"
   group.long 0x24--0x27 "MODEM_SBI0_STATUS (at 0x90004524)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CLK_OFF_STATUS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   I3Q_MODE_RD                    = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID_RD                    = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_MODE_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   DIAG_MODE_RD                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MSM_SBI_EN_RD                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MCHN_STATE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MCHN_BUSY                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RDBUF_FULL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WRBUF_FULL                     = " "0,1 "
  tree.end
  tree "MODEM_SBI1_STATUS"
   group.long 0x64--0x67 "MODEM_SBI1_STATUS (at 0x90004564)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   CLK_OFF_STATUS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   I3Q_MODE_RD                    = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID_RD                    = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_MODE_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   DIAG_MODE_RD                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MSM_SBI_EN_RD                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MCHN_STATE                     = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MCHN_BUSY                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RDBUF_FULL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WRBUF_FULL                     = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_BYPASS_RD"
  tree "MODEM_SBI0_BYPASS_RD"
   group.long 0x28--0x2b "MODEM_SBI0_BYPASS_RD (at 0x90004528)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SBCK_PIN_STATUS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OVR_SBCK_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   OVR_SBST_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_SBDT_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SBDT_PIN_STATUS                = " "0,1 "
  tree.end
  tree "MODEM_SBI1_BYPASS_RD"
   group.long 0x68--0x6b "MODEM_SBI1_BYPASS_RD (at 0x90004568)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SBCK_PIN_STATUS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OVR_SBCK_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   OVR_SBST_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_SBDT_RD                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SBDT_PIN_STATUS                = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SBIc_RD"
  tree "MODEM_SBI0_RD"
   group.long 0x2c--0x2f "MODEM_SBI0_RD (at 0x9000452c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
  tree "MODEM_SBI1_RD"
   group.long 0x6c--0x6f "MODEM_SBI1_RD (at 0x9000456c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
 tree.end
 tree "MODEM_SBIc_RD1"
  tree "MODEM_SBI0_RD1"
   group.long 0x30--0x33 "MODEM_SBI0_RD1 (at 0x90004530)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR1                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA1                      = "
  tree.end
  tree "MODEM_SBI1_RD1"
   group.long 0x70--0x73 "MODEM_SBI1_RD1 (at 0x90004570)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR1                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA1                      = "
  tree.end
 tree.end
 tree "MODEM_SBIc_RD2"
  tree "MODEM_SBI0_RD2"
   group.long 0x34--0x37 "MODEM_SBI0_RD2 (at 0x90004534)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR2                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA2                      = "
  tree.end
  tree "MODEM_SBI1_RD2"
   group.long 0x74--0x77 "MODEM_SBI1_RD2 (at 0x90004574)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI1_RD2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RD_WR_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   REG_ADDR2                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA2                      = "
  tree.end
 tree.end
 tree "MODEM_SSBIc_CLK_EN"
  tree "MODEM_SSBI0_CLK_EN"
   group.long 0xe0--0xe3 "MODEM_SSBI0_CLK_EN (at 0x900045e0)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI0_CLK_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN                         = " "0,1 "
  tree.end
  tree "MODEM_SSBI1_CLK_EN"
   group.long 0xe4--0xe7 "MODEM_SSBI1_CLK_EN (at 0x900045e4)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI1_CLK_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN                         = " "0,1 "
  tree.end
  tree "MODEM_SSBI2_CLK_EN"
   group.long 0xe8--0xeb "MODEM_SSBI2_CLK_EN (at 0x900045e8)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI2_CLK_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN                         = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SSBIc_CGC_HW_EN"
  tree "MODEM_SSBI0_CGC_HW_EN"
   group.long 0xf0--0xf3 "MODEM_SSBI0_CGC_HW_EN (at 0x900045f0)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI0_CGC_HW_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CGC_HW_EN                      = " "0,1 "
  tree.end
  tree "MODEM_SSBI1_CGC_HW_EN"
   group.long 0xf4--0xf7 "MODEM_SSBI1_CGC_HW_EN (at 0x900045f4)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI1_CGC_HW_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CGC_HW_EN                      = " "0,1 "
  tree.end
  tree "MODEM_SSBI2_CGC_HW_EN"
   group.long 0xf8--0xfb "MODEM_SSBI2_CGC_HW_EN (at 0x900045f8)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI2_CGC_HW_EN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CGC_HW_EN                      = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SSBIc_CTL"
  tree "MODEM_SSBI0_CTL"
   group.long 0x80--0x83 "MODEM_SSBI0_CTL (at 0x90004580)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI0_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   WAKEUP_FINAL_CNT               = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SSBI_DATA_PDEN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ACTIVATE_RESERVE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DISABLE_TERM_SYM               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID                       = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FTM_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   SEL_RD_DATA                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_SSBI_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SSBI_DATA_DEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IDLE_SYMS                      = " "0,1,2,3 "
  tree.end
  tree "MODEM_SSBI1_CTL"
   group.long 0xa0--0xa3 "MODEM_SSBI1_CTL (at 0x900045a0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   WAKEUP_FINAL_CNT               = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SSBI_DATA_PDEN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ACTIVATE_RESERVE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DISABLE_TERM_SYM               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID                       = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FTM_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   SEL_RD_DATA                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_SSBI_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SSBI_DATA_DEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IDLE_SYMS                      = " "0,1,2,3 "
  tree.end
  tree "MODEM_SSBI2_CTL"
   group.long 0xc0--0xc3 "MODEM_SSBI2_CTL (at 0x900045c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   WAKEUP_FINAL_CNT               = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SSBI_DATA_PDEN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ACTIVATE_RESERVE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DISABLE_TERM_SYM               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID                       = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FTM_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   SEL_RD_DATA                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_SSBI_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SSBI_DATA_DEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IDLE_SYMS                      = " "0,1,2,3 "
  tree.end
 tree.end
 tree "MODEM_SSBIc_RESET"
  tree "MODEM_SSBI0_RESET"
   group.long 0x84--0x87 "MODEM_SSBI0_RESET (at 0x90004584) "
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_SSBI1_RESET"
   group.long 0xa4--0xa7 "MODEM_SSBI1_RESET (at 0x900045a4) "
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_SSBI2_RESET"
   group.long 0xc4--0xc7 "MODEM_SSBI2_RESET (at 0x900045c4) "
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "MODEM_SSBIc_CMD"
  tree "MODEM_SSBI0_CMD"
   group.long 0x88--0x8b "MODEM_SSBI0_CMD (at 0x90004588) "
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_SSBI1_CMD"
   group.long 0xa8--0xab "MODEM_SSBI1_CMD (at 0x900045a8)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI1_CMD to read/write)"
    line.long 0x0 "VALUE"
  tree.end
  tree "MODEM_SSBI2_CMD"
   group.long 0xc8--0xcb "MODEM_SSBI2_CMD (at 0x900045c8)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI2_CMD to read/write)"
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "MODEM_SSBIc_BYPASS"
  tree "MODEM_SSBI0_BYPASS"
   group.long 0x8c--0x8f "MODEM_SSBI0_BYPASS (at 0x9000458c)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI0_BYPASS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_VALUE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_MODE                       = " "0,1 "
  tree.end
  tree "MODEM_SSBI1_BYPASS"
   group.long 0xac--0xaf "MODEM_SSBI1_BYPASS (at 0x900045ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_VALUE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_MODE                       = " "0,1 "
  tree.end
  tree "MODEM_SSBI2_BYPASS"
   group.long 0xcc--0xcf "MODEM_SSBI2_BYPASS (at 0x900045cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_VALUE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_MODE                       = " "0,1 "
  tree.end
 tree.end
 tree "MODEM_SSBIc_PRIORITIES"
  tree "MODEM_SSBI0_PRIORITIES"
   group.long 0x98--0x9b "MODEM_SSBI0_PRIORITIES (at 0x90004598) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0x11 "  [17:15]   PRIORITY5                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   PRIORITY4                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   PRIORITY3                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   PRIORITY2                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   PRIORITY1                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY0                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MODEM_SSBI1_PRIORITIES"
   group.long 0xb8--0xbb "MODEM_SSBI1_PRIORITIES (at 0x900045b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0x11 "  [17:15]   PRIORITY5                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   PRIORITY4                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   PRIORITY3                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   PRIORITY2                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   PRIORITY1                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY0                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "MODEM_SSBI2_PRIORITIES"
   group.long 0xd8--0xdb "MODEM_SSBI2_PRIORITIES (at 0x900045d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0x11 "  [17:15]   PRIORITY5                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   PRIORITY4                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   PRIORITY3                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   PRIORITY2                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   PRIORITY1                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY0                      = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "MODEM_SSBIc_RD"
  tree "MODEM_SSBI0_RD"
   group.long 0x90--0x93 "MODEM_SSBI0_RD (at 0x90004590)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   USE_ENABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   RDWRN                          = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REG_ADD                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
  tree "MODEM_SSBI1_RD"
   group.long 0xb0--0xb3 "MODEM_SSBI1_RD (at 0x900045b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   USE_ENABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   RDWRN                          = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REG_ADD                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
  tree "MODEM_SSBI2_RD"
   group.long 0xd0--0xd3 "MODEM_SSBI2_RD (at 0x900045d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   USE_ENABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   RDWRN                          = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REG_ADD                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
 tree.end
 tree "MODEM_SSBIc_STATUS"
  tree "MODEM_SSBI0_STATUS"
   group.long 0x94--0x97 "MODEM_SSBI0_STATUS (at 0x90004594)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI_DATA_IN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RD_CLOBBERED                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RD_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   READY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCHN_BUSY                      = " "0,1 "
  tree.end
  tree "MODEM_SSBI1_STATUS"
   group.long 0xb4--0xb7 "MODEM_SSBI1_STATUS (at 0x900045b4)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI1_STATUS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI_DATA_IN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RD_CLOBBERED                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RD_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   READY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCHN_BUSY                      = " "0,1 "
  tree.end
  tree "MODEM_SSBI2_STATUS"
   group.long 0xd4--0xd7 "MODEM_SSBI2_STATUS (at 0x900045d4)   (shadowed - Use hwio_shadow_ptr->MODEM_SSBI2_STATUS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI_DATA_IN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RD_CLOBBERED                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RD_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   READY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCHN_BUSY                      = " "0,1 "
  tree.end
 tree.end
  tree "MODEM_SBI_PIN_CFG"
   group.long 0x100--0x103 "MODEM_SBI_PIN_CFG (at 0x90004600)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI_PIN_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BENIGN                         = " "0,1 "
  tree.end
  tree "MODEM_SBI_INOUT_CONFIG"
   group.long 0x104--0x107 "MODEM_SBI_INOUT_CONFIG (at 0x90004604)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI_INOUT_CONFIG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MSBI_INOUT2_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MSBI_INOUT1_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MSBI_INOUT0_SEL                = " "0,1 "
  tree.end
  tree "MODEM_SBI_RXF_AGC_CONFIG"
   group.long 0x108--0x10b "MODEM_SBI_RXF_AGC_CONFIG (at 0x90004608)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI_RXF_AGC_CONFIG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   AGC1_HOST_SEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AGC0_HOST_SEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RXF1_HOST_SEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RXF0_HOST_SEL                  = " "0,1,2,3 "
  tree.end
  tree "MODEM_SBI_INTR_MASK"
   group.long 0x10c--0x10f "MODEM_SBI_INTR_MASK (at 0x9000460c)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI_INTR_MASK to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI2_INTR_MASK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SSBI1_INTR_MASK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SSBI0_INTR_MASK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SBI1_INTR_MASK                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SBI0_INTR_MASK                 = " "0,1 "
  tree.end
  tree "MODEM_SBI_INTR_STATUS"
   group.long 0x114--0x117 "MODEM_SBI_INTR_STATUS (at 0x90004614)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI2_INTR_STATUS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SSBI1_INTR_STATUS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SSBI0_INTR_STATUS              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SBI1_INTR_STATUS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SBI0_INTR_STATUS               = " "0,1 "
  tree.end
  tree "MODEM_SBI_BUGFIX_DISABLE"
   group.long 0x118--0x11b "MODEM_SBI_BUGFIX_DISABLE (at 0x90004618)   (shadowed - Use hwio_shadow_ptr->MODEM_SBI_BUGFIX_DISABLE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MULTIBYTE                      = " "0,1 "
  tree.end
  tree "MODEM_SBI_EXT_SSBI_CLK_FORCE_ON"
   group.long 0x11c--0x11f "MODEM_SBI_EXT_SSBI_CLK_FORCE_ON (at 0x9000461c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SSBI2_FORCE_ON                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SSBI1_FORCE_ON                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SSBI0_FORCE_ON                 = " "0,1 "
  tree.end
  tree "MODEM_SBI_EXT_SSBI_CLK_DLY"
   group.long 0x120--0x123 "MODEM_SBI_EXT_SSBI_CLK_DLY (at 0x90004620) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DLY_NUM                        = "
  tree.end
tree.end

base ad:0x90004800
tree "MODEM_WEB"
  tree "MODEM_HW_REV_RD"
   group.long 0x0--0x3 "MODEM_HW_REV_RD (at 0x90004800)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   MODEM_HW_REV_RD                = "
  tree.end
  tree "MODEM_MISC_CFG0"
   group.long 0x8--0xb "MODEM_MISC_CFG0 (at 0x90004808) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GPS_ANT_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   GPS_TEST_SAMPLES               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   RESERVED_BITS29_28             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   ANT1_SAMPLE_RESET_SHIFT        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   ANT0_SAMPLE_RESET_SHIFT        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   ANT1_FIFO_BYPASS_N             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   ANT0_FIFO_BYPASS_N             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BITS23                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   VFR_CTL                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   VFR_SRC_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   VFR_EN                         = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xe--0x13 1 "  [19:14]   MDSP_DBG_BUS_SEL               = "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SLEEPB_BBR_ORIDE_VAL           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SLEEPB_BBR_GRFC_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MDSP_CM_SW_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BITS10                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   FORCE_SYNTH_LOCK               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MDSP_TXDAC_SW_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GSM_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CDMA_RX1_ANT_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CDMA_RX0_ANT_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   GSM_ANT_SEL                    = " "0 (ANTENNA_0_SAMPLES),1 (ANTENNA_1_SAMPLES) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RESERVED_BITS3_2               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX_ANT_SRC_DBG                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VFR_IRQ_SRC_DBG                = " "0,1 "
  tree.end
  tree "MODEM_MISC_CFG1"
   group.long 0xc--0xf "MODEM_MISC_CFG1 (at 0x9000480c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   PCDAC_IOUT_VOUT_SEL_GRFC_EN    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   PCDAC_OUTOPA_EN_GRFC_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   PCDAC_GC_GRFC_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   TX_ON_ALT_SEL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   TX_ON_GRFC_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   PCDAC_GRFC20_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x17 "  [23:21]   PCDAC_OUTOPA_CTL               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x12--0x14 "  [20:18]   PCDAC_DECOPA_CTL               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   PCDAC_DCOFFSET_EN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   PCDAC_HGAIN_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   PCDAC_IREFIN_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   PCDAC_DACIN_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   PCDAC_REFDECIN_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PCDAC_REFIN_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   PCDAC_GC                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PCDAC_DACOUTB_SEL              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PCDAC_DCOPAOUT_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PCDAC_BGOUT_SEL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   PCDAC_OUTNODE_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PCDAC_IOUT_VOUT_SEL            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PCDAC_OUTOPA_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PDDAC_IREFRTR_DECOPA_SEL       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PCDAC_DECOPA_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PCDAC_BG_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PCDAC_DAC2_EN                  = " "0,1 "
  tree.end
  tree "MODEM_MISC_CFG2"
   group.long 0x10--0x13 "MODEM_MISC_CFG2 (at 0x90004810) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_ACTIVE_SEL                  = " "0,1 "
  tree.end
  tree "MODEM_TX_DAC_SLEEP"
   group.long 0x14--0x17 "MODEM_TX_DAC_SLEEP (at 0x90004814) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DAC_SLEEP                   = " "0,1 "
  tree.end
  tree "MODEM_DBG_BUS_OUT_GATING"
   group.long 0x18--0x1b "MODEM_DBG_BUS_OUT_GATING (at 0x90004818) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   GATE_DBG_BUS                   = "
  tree.end
  tree "MODEM_WEB_SPARE_READ_REG0"
   group.long 0x20--0x23 "MODEM_WEB_SPARE_READ_REG0 (at 0x90004820)   (shadowed - Use hwio_shadow_ptr->MODEM_WEB_SPARE_READ_REG0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WRITE_VAL                      = "
  tree.end
  tree "MODEM_GENERIC_CTL_REG"
   group.long 0x24--0x27 "MODEM_GENERIC_CTL_REG (at 0x90004824) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   TX_INT_SEL                     = " "0 (SELECT_THE_TX_SLOT_INTERRUPT),1 (SELECT_THE_TX_64_CHIP_INTERRUPT) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   MDSP_IRQ_TEST_EN               = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   HDEM_TESTBUS_EN                = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MDSP_IRQ_SEL                   = " "0 (HDR),1 (GSM),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   TRK_LO_ADJ_SEL                 = " "0 (CDMA_1X),1 (HDR) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TX_AGC_CTL_SEL                 = " "0 (CHAIN_0),1 (CHAIN_1) "
  tree.end
  tree "MODEM_BRIDGE_TIMEOUT_CFG"
   group.long 0x28--0x2b "MODEM_BRIDGE_TIMEOUT_CFG (at 0x90004828) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   TIMEOUT_EN_MDM                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   RESERVED_BIT25                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   TIMEOUT_EN_MODEM               = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   TIMEOUT_VAL_MDM                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TIMEOUT_VAL_MODEM              = "
  tree.end
  tree "MODEM_PA_ON_STATUS"
   group.long 0x2c--0x2f "MODEM_PA_ON_STATUS (at 0x9000482c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PA_ON_2                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   PA_ON_1                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   PA_ON_0                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   PA_ON                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TX_ON                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PA_VALID                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TX_VALID                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PA_ON_DISABLE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SYNTH_LOCK_GATED               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SYNTH_LOCK                     = " "0,1 "
  tree.end
  tree "MODEM_PA_ON_CTL"
   group.long 0x30--0x33 "MODEM_PA_ON_CTL (at 0x90004830) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BYPASS_PA_ON_DISABLE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   BYPASS_TX_SYNTH_LOCK           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_TX_VALID                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TX_ON_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASS_PA_SYNTH_LOCK           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_PA_VALID                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   BAND_SEL                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_ON_EN                       = " "0,1 "
  tree.end
  tree "MODEM_PA_ON_PROTECTION"
   group.long 0x34--0x37 "MODEM_PA_ON_PROTECTION (at 0x90004834) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PA_ON_GUARD                    = " "0,1 "
  tree.end
  tree "MDM_SEC_DOMAIN_CFG"
   group.long 0x38--0x3b "MDM_SEC_DOMAIN_CFG (at 0x90004838) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x6--0x9 1 "  [ 9: 6]   MARM_IRQ_MASK                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   MDSP_IRQ_MASK                  = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MDSP_SEC_DOMAIN                = " "0,1,2,3 "
  tree.end
  tree "MODEM_WEB_DBG_BUS_SEL"
   group.long 0x3c--0x3f "MODEM_WEB_DBG_BUS_SEL (at 0x9000483c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DBG_BUS_OUT_SEL                = " "0 (RF_SIGNALS_DEBUG_BUS_TX_ON_AND_PA_ON),1 (ASYNC_FIFO_SAMPLE_RESYNC_CIRCUIT_DEBUG_BUSES_FOR_ANT0_AND_ANT1),2 (GRFC_CONTROLLED_SIGNALS),3 (GSM_AND_MMGPS_ANTENNA_SIGNALS_VFR_IRQ) "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE0"
   group.long 0x40--0x43 "MODEM_OUTPORT_OVERRIDE0 (at 0x90004840) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   TEST_VAL                       = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE1"
   group.long 0x44--0x47 "MODEM_OUTPORT_OVERRIDE1 (at 0x90004844) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   MDSP_GPIO_PO                   = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   MDSP_GPIO_OE                   = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   MODEM_TO_ADSP_IRQ              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   SBI_REQ                        = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   SBI_REQ_ID                     = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SBI_ADDR                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_DATA                       = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE2"
   group.long 0x48--0x4b "MODEM_OUTPORT_OVERRIDE2 (at 0x90004848) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   TEST_VAL                       = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE3"
   group.long 0x4c--0x4f "MODEM_OUTPORT_OVERRIDE3 (at 0x9000484c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x16 1 "  [22: 0]   GSM_GRFC_PO                    = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE4"
   group.long 0x50--0x53 "MODEM_OUTPORT_OVERRIDE4 (at 0x90004850) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x16 1 "  [22: 0]   GSM_GRFC_OE                    = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE5"
   group.long 0x54--0x57 "MODEM_OUTPORT_OVERRIDE5 (at 0x90004854) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x1a "  [26:25]   MODEM_CLK_DBG_OUT              = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   M_MICRO_IRQ_SRC                = "
  tree.end
  tree "MODEM_OUTPORT_OVERRIDE_EN"
   group.long 0x58--0x5b "MODEM_OUTPORT_OVERRIDE_EN (at 0x90004858) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EN                             = " "0,1 "
  tree.end
  tree "MODEM_INPORT_RD_DATA0"
   group.long 0x5c--0x5f "MODEM_INPORT_RD_DATA0 (at 0x9000485c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   RD_VAL                         = "
  tree.end
  tree "MODEM_INPORT_RD_DATA1"
   group.long 0x60--0x63 "MODEM_INPORT_RD_DATA1 (at 0x90004860)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   RD_VAL                         = "
  tree.end
  tree "MODEM_INPORT_RD_DATA2"
   group.long 0x64--0x67 "MODEM_INPORT_RD_DATA2 (at 0x90004864)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   RD_VAL                         = "
  tree.end
  tree "AGC_CARRIER_FREQ_ERR"
   group.long 0x68--0x6b "AGC_CARRIER_FREQ_ERR (at 0x90004868) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FREQ_ERR                       = "
  tree.end
  tree "AGC_FREQ_COMB_CTL"
   group.long 0x6c--0x6f "AGC_FREQ_COMB_CTL (at 0x9000486c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CARRIER_FREQ_TRK_ORIDE_N       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TRK_LO_ADJ_POL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TRK_LO_ADJ_OE                  = " "0,1 "
  tree.end
tree.end
tree.end
tree "PERIPH"
base ad:0x8000c000
tree "PERIPH_HCLK"
  tree "CHIP_MODE"
   group.long 0x0--0x3 "CHIP_MODE (at 0x8000c000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MODE2_PIN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MODE1_PIN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MODE0_PIN                      = " "0,1 "
  tree.end
  tree "WEB_MISC_WR"
   group.long 0x4--0x7 "WEB_MISC_WR (at 0x8000c004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x5--0x1c 1 "  [28: 5]   DBG_BUS_IN_NIBBLE_SEL          = "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   UIM_COLLAPSE_GPIO_15           = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   UIM_COLLAPSE_GPIO_14           = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   UIM_COLLAPSE_GPIO_12           = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   SERIAL_LCD_MODE                = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INV_TCXO_EN                    = " "0,1 "
  tree.end
  tree "EBI1_PAD_PULL_0"
   group.long 0x120--0x123 "EBI1_PAD_PULL_0 (at 0x8000c120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EBI1_CS_N1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   EBI1_CS_N0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   EBI1_LB_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EBI1_OE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EBI1_UB_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   EBI1_WE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EBI1_WAIT_N                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI1_ADV_N                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EBI1_A_D_BYTE1                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EBI1_A_D_BYTE0                 = " "0,1 "
  tree.end
  tree "EBI1_PAD_PULL_1"
   group.long 0x124--0x127 "EBI1_PAD_PULL_1 (at 0x8000c124) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EBI1_CS_N1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   EBI1_CS_N0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   EBI1_LB_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EBI1_OE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EBI1_UB_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   EBI1_WE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EBI1_WAIT_N                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI1_ADV_N                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EBI1_A_D_BYTE1                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EBI1_A_D_BYTE0                 = " "0,1 "
  tree.end
  tree "EBI2_PAD_PULL_0"
   group.long 0x128--0x12b "EBI2_PAD_PULL_0 (at 0x8000c128) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EBI2_LCD_CS1_N                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EBI2_LCD_CS0_N                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   EBI2_OE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EBI2_LCDEN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI2_WE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EBI2_LCDRS_ADV_N               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EBI2_A_D_BUS                   = " "0,1 "
  tree.end
  tree "EBI2_PAD_PULL_1"
   group.long 0x12c--0x12f "EBI2_PAD_PULL_1 (at 0x8000c12c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EBI2_LCD_CS1_N                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EBI2_LCD_CS0_N                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   EBI2_OE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EBI2_LCDEN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EBI2_WE_N                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EBI2_LCDRS_ADV_N               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EBI2_A_D_BUS                   = " "0,1 "
  tree.end
  tree "D2D_PAD_PULL_0"
   group.long 0x8--0xb "D2D_PAD_PULL_0 (at 0x8000c008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PM_PS_HOLD                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   AD_JD1_INT                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AD_SSBI_RX                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AD_SSBI_TX                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PM_SSBI                        = " "0,1 "
  tree.end
  tree "D2D_PAD_PULL_1"
   group.long 0xc--0xf "D2D_PAD_PULL_1 (at 0x8000c00c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PM_INT_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PM_PS_HOLD                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   AD_JD1_INT                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AD_SSBI_RX                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AD_SSBI_TX                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PM_SSBI                        = " "0,1 "
  tree.end
  tree "D2D_PAD_HDRIVE_MSEL_0"
   group.long 0x10--0x13 "D2D_PAD_HDRIVE_MSEL_0 (at 0x8000c010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_XO_EN                   = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_TX_ON                   = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_AD_PA_R0                = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_AD_SSBI_TX              = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_AD_SSBI_RX              = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_AD_PA_R1                = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_PM_SSBI                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_PS_HOLD                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "D2D_PAD_HDRIVE_MSEL_1"
   group.long 0x14--0x17 "D2D_PAD_HDRIVE_MSEL_1 (at 0x8000c014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_USB_DAT_VP              = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_USB_OE_INT_N            = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_USB_SE0_VM              = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "PAD_HDRIVE_MSEL"
   group.long 0x18--0x1b "PAD_HDRIVE_MSEL (at 0x8000c018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_RESOUT_N                = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_JTAG                    = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "EBI1_PAD_HDRIVE_MSEL_0"
   group.long 0x1c--0x1f "EBI1_PAD_HDRIVE_MSEL_0 (at 0x8000c01c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_EBI1_MEM_CLK            = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_EBI1_CS_N1              = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_EBI1_CS_N0              = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_EBI1_LB_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_EBI1_OE_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_EBI1_UB_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_EBI1_WE_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
  tree.end
  tree "EBI1_PAD_HDRIVE_MSEL_1"
   group.long 0x20--0x23 "EBI1_PAD_HDRIVE_MSEL_1 (at 0x8000c020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_EBI1_WAIT_N             = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_EBI1_ADV_N              = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_EBI1_A_D_BYTE1          = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_EBI1_A_D_BYTE0          = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
  tree.end
  tree "EBI2_PAD_HDRIVE_MSEL_0"
   group.long 0x24--0x27 "EBI2_PAD_HDRIVE_MSEL_0 (at 0x8000c024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_EBI2_A_D_BUS            = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_EBI2_LCDRS_ADV_N        = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_EBI2_LCD_CS1_N          = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_EBI2_LCD_CS0_N          = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_EBI2_LCDEN              = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_EBI2_OE_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_EBI2_WE_N               = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_0"
   group.long 0x30--0x33 "GPIO_PAD_HDRIVE_MSEL_0 (at 0x8000c030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_7                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_6                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_5                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_4                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_3                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_2                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_1                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_0                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_1"
   group.long 0x34--0x37 "GPIO_PAD_HDRIVE_MSEL_1 (at 0x8000c034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_15                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_14                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_13                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_12                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_11                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_10                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_9                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_8                  = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_2"
   group.long 0x38--0x3b "GPIO_PAD_HDRIVE_MSEL_2 (at 0x8000c038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_23                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_22                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_21                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_20                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_19                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_18                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_17                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_16                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_3"
   group.long 0x3c--0x3f "GPIO_PAD_HDRIVE_MSEL_3 (at 0x8000c03c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_31                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_30                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_29                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_28                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_27                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_26                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_25                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_24                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_4"
   group.long 0x40--0x43 "GPIO_PAD_HDRIVE_MSEL_4 (at 0x8000c040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_39                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_38                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_37                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_36                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_35                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_34                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_33                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_32                 = " "0 (2_MA),1 (4_MA),2 (6_MA),3 (8_MA),4 (10_MA),5 (12_MA),6 (14_MA),7 (16_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_5"
   group.long 0x44--0x47 "GPIO_PAD_HDRIVE_MSEL_5 (at 0x8000c044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_47                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_46                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_45                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_44                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_43                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_42                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_41                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_40                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_6"
   group.long 0x48--0x4b "GPIO_PAD_HDRIVE_MSEL_6 (at 0x8000c048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BIT31                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   HDRIVE_GPIO_55                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_54                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_53                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_52                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_51                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_50                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_49                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_48                 = " "0 (1_MA),1 (2_MA),2 (3_MA),3 (4_MA),4 (5_MA),5 (6_MA),6 (7_MA),7 (8_MA) "
  tree.end
  tree "GPIO_PAD_HDRIVE_MSEL_7"
   group.long 0x4c--0x4f "GPIO_PAD_HDRIVE_MSEL_7 (at 0x8000c04c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BIT27                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   HDRIVE_GPIO_62                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BIT23                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   HDRIVE_GPIO_61                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BIT19                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   HDRIVE_GPIO_60                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   HDRIVE_GPIO_59                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HDRIVE_GPIO_58                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HDRIVE_GPIO_57                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDRIVE_GPIO_56                 = " "0 (4_MA),1 (4_4_MA),2 (4_8_MA),3 (5_2_MA),4 (5_6_MA),5 (6_MA),6 (6_4_MA),7 (6_8_MA) "
  tree.end
  tree "PMIC_CONTROL"
   group.long 0x100--0x103 "PMIC_CONTROL (at 0x8000c100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TCXO_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PS_HOLD_OE                     = " "0,1 "
  tree.end
  tree "ANALOG_TEST_SEL"
   group.long 0x58--0x5b "ANALOG_TEST_SEL (at 0x8000c058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SEL_SSBI_RX_TEST               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SEL_SSBI_TX_TEST               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_PM_SSBI_TEST               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SEL_SSBI_MS_TEST               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SEL_AD_TEST                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_TXDAC_TEST                 = " "0,1 "
  tree.end
  tree "ADIE_TEST_CONTROL"
   group.long 0x5c--0x5f "ADIE_TEST_CONTROL (at 0x8000c05c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TEST_SSBI_MS                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   TEST_SSBI_RX                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   TEST_SSBI_RX_OE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   TEST_SSBI_TX                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TEST_SSBI_TX_OE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   TEST_PA_R1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   TEST_PA_R0                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TEST_TX_ON                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x5--0x8 1 "  [ 8: 5]   TEST_CODEC_DI                  = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_BBRX_CKIN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TEST_CODEC_CLK_2X              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TEST_CODEC_CLK                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_PM_SSBI                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_PM_SSBI_OE                = " "0,1 "
  tree.end
  tree "TXDAC_TEST_CONTROL"
   group.long 0x60--0x63 "TXDAC_TEST_CONTROL (at 0x8000c060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x11--0x1c 1 "  [28:17]   TEST_I_DATA                    = "
    textline ""
    hexmask.long.word 0x0 0x5--0x10 1 "  [16: 5]   TEST_Q_DATA                    = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_TXDAC_CLK                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TEST_TXDAC_SLEEP               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TXDAC_IREFIN_OUTB              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TXDAC_IQ_SEL                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXDAC_EN                       = " "0,1 "
  tree.end
  tree "HW_REVISION_NUMBER"
   group.long 0x64--0x67 "HW_REVISION_NUMBER (at 0x8000c064)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   VERSION_ID                     = "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   FOUNDARY                       = " "0 (TSMC),1 (CHARTERED),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (6_8_MA) "
    textline ""
    hexmask.long.word 0x0 0x10--0x18 1 "  [24:16]   PARTNUM                        = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   CHIP_ID                        = "
    textline ""
    hexmask.long.word 0x0 0x1--0xb 1 "  [11: 1]   QUALCOMM_MFG_ID                = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_BIT                      = " "0,1 "
  tree.end
  tree "CHIP_FEATURE_ID"
   group.long 0x68--0x6b "CHIP_FEATURE_ID (at 0x8000c068)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FEATURE_ID                     = "
  tree.end
  tree "USB_GPIO_TEST"
   group.long 0x130--0x133 "USB_GPIO_TEST (at 0x8000c130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   USB_GPIO_TEST                  = " "0,1 "
  tree.end
  tree "SSBI_GPIO_TEST"
   group.long 0x134--0x137 "SSBI_GPIO_TEST (at 0x8000c134) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PM_SSBI_GPIO_TEST              = " "0,1 "
  tree.end
  tree "USB_PIN_CONFIG"
   group.long 0x7c--0x7f "USB_PIN_CONFIG (at 0x8000c07c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   REG_OE_INT_N_OE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   REG_INT_N_OUT_N                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   REG_DAT_OE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   REG_DAT_OUT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   REG_SE0_OE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   REG_SE0_OUT                    = " "0,1 "
  tree.end
  tree "USB_PIN_SEL"
   group.long 0x80--0x83 "USB_PIN_SEL (at 0x8000c080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_PIN_SEL                    = " "0 (USB_MODE),1 (USB_PIN_VALUES_AREFROM_USB_PIN_CFG_REGISTER),2 (UART1),3 (UART2) "
  tree.end
  tree "TEST_BUS_EN"
   group.long 0x84--0x87 "TEST_BUS_EN (at 0x8000c084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xe--0x1c 1 "  [28:14]   TEST_BUS_NIBBLE_SEL            = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xd 1 "  [13: 9]   TEST_BUS_MUX_SEL               = "
    textline ""
    hexmask.long.word 0x0 0x1--0x8 1 "  [ 8: 1]   ADSP_TEST_BUS_SEL              = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ADSP_TEST_BUS_EN               = " "0,1 "
  tree.end
  tree "PMBLK_CONFIG"
   group.long 0x88--0x8b "PMBLK_CONFIG (at 0x8000c088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CLK_EN4                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CLK_EN3                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   CLK_EN2                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CLK_EN1                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DIVIDE_SEL                     = " "0 (DIVIDE_BY_16),1 (DIVIDE_BY_128),2 (DIVIDE_BY_512),3 (DIVIDE_BY_1024) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEVICE_SEL                     = " "0 (HVT),1 (NVT),2 (LVT),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RINGOSC_SEL                    = " "0 (RINGOSC_0),1 (RINGOSC_1),2 (RINGOSC_2),3 (RINGOSC_3),4 (RINGOSC_4),5 (RINGOSC_5),6 (RINGOSC_6),7 (RINGOSC_7) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_EN0                        = " "0,1 "
  tree.end
  tree "PMBLK_CNT0"
   group.long 0x8c--0x8f "PMBLK_CNT0 (at 0x8000c08c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CNT                            = "
  tree.end
  tree "PMBLK_CNT1"
   group.long 0x90--0x93 "PMBLK_CNT1 (at 0x8000c090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CNT                            = "
  tree.end
  tree "PMBLK_CNT2"
   group.long 0x94--0x97 "PMBLK_CNT2 (at 0x8000c094)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CNT                            = "
  tree.end
  tree "PMBLK_CNT3"
   group.long 0x98--0x9b "PMBLK_CNT3 (at 0x8000c098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CNT                            = "
  tree.end
  tree "PMBLK_CNT4"
   group.long 0x9c--0x9f "PMBLK_CNT4 (at 0x8000c09c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   CNT                            = "
  tree.end
tree.end

base ad:0x8000e000
tree "PERIPH_XO4"
  tree "TIME_TICK_CTL"
   group.long 0xa4--0xa7 "TIME_TICK_CTL (at 0x8000e0a4)   (shadowed - Use hwio_shadow_ptr->TIME_TICK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RATE_SEL                       = " "0 (1_25_MS),1 (2_5_MS),2 (5_MS),3 (10_MS) "
  tree.end
  tree "TIME_TICK_INT_MSB"
   group.long 0xa8--0xab "TIME_TICK_INT_MSB (at 0x8000e0a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA7_0                        = "
  tree.end
tree.end
tree.end
tree "PERPH"
base ad:0x80030000
tree "PERPH_WEB_I2C"
  tree "I2C_WRITE_DATA"
   group.long 0x0--0x3 "I2C_WRITE_DATA (at 0x80030000)   (shadowed - Use hwio_shadow_ptr->I2C_WRITE_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   LAST_BYTE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ADDR_BYTE                      = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "I2C_CLK_CTL"
   group.long 0x4--0x7 "I2C_CLK_CTL (at 0x80030004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   HS_DIVIDER_VALUE               = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FS_DIVIDER_VALUE               = "
  tree.end
  tree "I2C_STATUS"
   group.long 0x8--0xb "I2C_STATUS (at 0x80030008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   CLK_STATE                      = " "0 (RESET_BUSIDLE_STATE),1 (NOT_MASTER_STATE),2 (HIGH_STATE),3 (LOW_STATE),4 (HIGH_WAIT_STATE),5 (FORCED_LOW_STATE),6 (HS_ADDR_LOW_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0xa--0xc "  [12:10]   DATA_STATE                     = " "0 (RESET_WAIT_STATE),1 (TX_ADDR_STATE),2 (TX_DATA_STATE),3 (TX_HS_ADDR_STATE),4 (TX_10_BIT_ADDR_STATE),5 (TX_2ND_BYTE_STATE),6 (RX_DATA_STATE),7 (DOUBLE_BUFFER_WAIT_STATE) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BUS_MASTER                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   BUS_ACTIVE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FAILED                         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   INVALID_WRITE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ARB_LOST                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PACKET_NACKED                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BUS_ERROR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RD_BUFFER_FULL                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   WR_BUFFER_FULL                 = " "0,1 "
  tree.end
  tree "I2C_READ_DATA"
   group.long 0xc--0xf "I2C_READ_DATA (at 0x8003000c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_BYTE                      = "
  tree.end
  tree "I2C_INTERFACE_SELECT"
   group.long 0x10--0x13 "I2C_INTERFACE_SELECT (at 0x80030010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SDA                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SCL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BITS7_6               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   TEST_DATA                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_CLK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTF_SELECT                    = " "0,1 "
  tree.end
tree.end

base ad:0x80030000
tree "PERPH_WEB_XO4"
  tree "TCXO_PDM_CTL"
   group.long 0x40--0x43 "TCXO_PDM_CTL (at 0x80030040)   (shadowed - Use hwio_shadow_ptr->TCXO_PDM_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x5--0x1f 1 "  [31: 5]   RESERVED_BITS31_5              = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PDM1_POLARITY                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   PDM0_POLARITY                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RESERVED_BIT2                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PDM1_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PDM0_EN                        = " "0,1 "
  tree.end
  tree "PDM0_CTL"
   group.long 0x44--0x47 "PDM0_CTL (at 0x80030044)   (shadowed - Use hwio_shadow_ptr->PDM0_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   PDM0_DAT                       = "
  tree.end
  tree "PDM1_CTL"
   group.long 0x48--0x4b "PDM1_CTL (at 0x80030048)   (shadowed - Use hwio_shadow_ptr->PDM1_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   PDM1_DAT                       = "
  tree.end
  tree "GP_MN_CLK_MDIV"
   group.long 0x4c--0x4f "GP_MN_CLK_MDIV (at 0x8003004c)   (shadowed - Use hwio_shadow_ptr->GP_MN_CLK_MDIV to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   GP_M_VALUE                     = "
  tree.end
  tree "GP_MN_CLK_NDIV"
   group.long 0x50--0x53 "GP_MN_CLK_NDIV (at 0x80030050)   (shadowed - Use hwio_shadow_ptr->GP_MN_CLK_NDIV to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   GP_N_VALUE                     = "
  tree.end
  tree "GP_MN_CLK_DUTY"
   group.long 0x54--0x57 "GP_MN_CLK_DUTY (at 0x80030054)   (shadowed - Use hwio_shadow_ptr->GP_MN_CLK_DUTY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   GP_D_VALUE                     = "
  tree.end
  tree "WEB_TCXO4_TEST"
   group.long 0x58--0x5b "WEB_TCXO4_TEST (at 0x80030058)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   RESERVED15_10                  = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   GP_MN_EDGE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   GP_MN                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED7_6                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PDM1_EDGE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PDM1                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RESERVED3_2                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PDM0_EDGE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PDM0                           = " "0,1 "
  tree.end
tree.end
tree.end

base ad:0x90003500
tree "QLIC"
  tree "QLIC_MTI_CTL"
   group.long 0x0--0x3 "QLIC_MTI_CTL (at 0x90003500)   (shadowed - Use hwio_shadow_ptr->QLIC_MTI_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   MTI_ADDR                       = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   COMBRAM1_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   COMBRAM0_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SECRAM_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   O_RAM_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   FERAM1_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FERAM0_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MTI_WE                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MTI_OE                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MTI_TE                         = " "0,1 "
  tree.end
  tree "QLIC_FERAM0_WORD0"
   group.long 0x4--0x7 "QLIC_FERAM0_WORD0 (at 0x90003504)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   FERAM0_WORD0                   = "
  tree.end
  tree "QLIC_FERAM0_WORD1"
   group.long 0x8--0xb "QLIC_FERAM0_WORD1 (at 0x90003508)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   FERAM0_WORD1                   = "
  tree.end
  tree "QLIC_FERAM1_WORD0"
   group.long 0xc--0xf "QLIC_FERAM1_WORD0 (at 0x9000350c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   FERAM1_WORD0                   = "
  tree.end
  tree "QLIC_FERAM1_WORD1"
   group.long 0x10--0x13 "QLIC_FERAM1_WORD1 (at 0x90003510)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   FERAM1_WORD1                   = "
  tree.end
  tree "QLIC_OMGRAM_WORD0"
   group.long 0x14--0x17 "QLIC_OMGRAM_WORD0 (at 0x90003514)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   O_RAM_WORD0                    = "
  tree.end
  tree "QLIC_OMGRAM_WORD1"
   group.long 0x18--0x1b "QLIC_OMGRAM_WORD1 (at 0x90003518)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1d 1 "  [29: 0]   O_RAM_WORD1                    = "
  tree.end
  tree "QLIC_SECRAM_WORD0"
   group.long 0x1c--0x1f "QLIC_SECRAM_WORD0 (at 0x9000351c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   SECRAM_WORD0                   = "
  tree.end
  tree "QLIC_SECRAM_WORD1"
   group.long 0x20--0x23 "QLIC_SECRAM_WORD1 (at 0x90003520)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   SECRAM_WORD1                   = "
  tree.end
  tree "QLIC_COMBRAM0_WORD0"
   group.long 0x24--0x27 "QLIC_COMBRAM0_WORD0 (at 0x90003524)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM0_WORD0                 = "
  tree.end
  tree "QLIC_COMBRAM0_WORD1"
   group.long 0x28--0x2b "QLIC_COMBRAM0_WORD1 (at 0x90003528)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM0_WORD1                 = "
  tree.end
  tree "QLIC_COMBRAM0_WORD2"
   group.long 0x2c--0x2f "QLIC_COMBRAM0_WORD2 (at 0x9000352c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM0_WORD2                 = "
  tree.end
  tree "QLIC_COMBRAM1_WORD0"
   group.long 0x30--0x33 "QLIC_COMBRAM1_WORD0 (at 0x90003530)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM1_WORD0                 = "
  tree.end
  tree "QLIC_COMBRAM1_WORD1"
   group.long 0x34--0x37 "QLIC_COMBRAM1_WORD1 (at 0x90003534)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM1_WORD1                 = "
  tree.end
  tree "QLIC_COMBRAM1_WORD2"
   group.long 0x38--0x3b "QLIC_COMBRAM1_WORD2 (at 0x90003538)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMBRAM1_WORD2                 = "
  tree.end
  tree "QLIC_CGC_TASK_STATE_ARM"
   group.long 0x3c--0x3f "QLIC_CGC_TASK_STATE_ARM (at 0x9000353c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TASK_CTL_STATE                 = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   OFFLINE_HALT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BE_CGC_HALT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   QE_CGC_HALT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FE_CGC_HALT                    = " "0,1 "
  tree.end
  tree "QLIC_TESTBUS_ARM"
   group.long 0x4c--0x4f "QLIC_TESTBUS_ARM (at 0x9000354c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TESTBUS                        = "
  tree.end
tree.end

base ad:0x80020000
tree "QMEMBIST"
  tree "QMEMBIST_CLK_ENA"
   group.long 0x0--0x3 "QMEMBIST_CLK_ENA (at 0x80020000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_ENA                        = " "0,1 "
  tree.end
  tree "QMEMBIST_IO_CFG"
   group.long 0x4--0x7 "QMEMBIST_IO_CFG (at 0x80020004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BIST_FAIL_SET_SEL              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BIST_FA_DATA_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BIST_FAIL_EN                   = " "0,1 "
  tree.end
  tree "QMEMBIST_RESET"
   group.long 0x8--0xb "QMEMBIST_RESET (at 0x80020008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SW_RESET                       = " "0,1 "
  tree.end
  tree "QMEMBIST_FA_SEQUENCER_SEL"
   group.long 0xc--0xf "QMEMBIST_FA_SEQUENCER_SEL (at 0x8002000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   FA_SEQUENCER_SEL               = "
  tree.end
  tree "QMEMBIST_EMBEDDED_ALG_CFG"
   group.long 0x10--0x13 "QMEMBIST_EMBEDDED_ALG_CFG (at 0x80020010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   ALGORITHM_SEL_MAP              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   REPLACE_RIPPLE_MODE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RIPPLE_ROW                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   REPLACE_PATTERNS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   INVERT_BITS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   INVERT_ROWS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_COLUMNS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   OPTIMIZE_BLANKET_MARCH         = " "0 (REGULAR_BLANKET_MARCH),1 (OPTIMIZED_BLANKET_MARCH) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PAUSE                          = " "0,1 "
  tree.end
  tree "QMEMBIST_USR_CMD_DESTINATION"
   group.long 0x14--0x17 "QMEMBIST_USR_CMD_DESTINATION (at 0x80020014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ID                         = "
  tree.end
  tree "QMEMBIST_USR_CMD_CFG"
   group.long 0x18--0x1b "QMEMBIST_USR_CMD_CFG (at 0x80020018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1c 1 "  [28: 0]   SEQUENCER_COMMAND              = "
  tree.end
  tree "QMEMBIST_TEST_TRIGGER"
   group.long 0x1c--0x1f "QMEMBIST_TEST_TRIGGER (at 0x8002001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   START_USR_CMD                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CONT_EMBEDDED_ALG              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_EMBEDDED_ALG             = " "0,1 "
  tree.end
  tree "QMEMBIST_TEST_STATUS"
   group.long 0x20--0x23 "QMEMBIST_TEST_STATUS (at 0x80020020)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PAUSED                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DONE                           = " "0,1 "
  tree.end
 tree "QMEMBIST_TESTEDm"
  tree "QMEMBIST_TESTED0"
   group.long 0x24--0x27 "QMEMBIST_TESTED0 (at 0x80020024)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "QMEMBIST_TESTED1"
   group.long 0x28--0x2b "QMEMBIST_TESTED1 (at 0x80020028)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "QMEMBIST_TESTED2"
   group.long 0x2c--0x2f "QMEMBIST_TESTED2 (at 0x8002002c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
  tree "QMEMBIST_TESTED3"
   group.long 0x30--0x33 "QMEMBIST_TESTED3 (at 0x80020030)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_TESTED                 = "
  tree.end
 tree.end
 tree "QMEMBIST_FAILEDm"
  tree "QMEMBIST_FAILED0"
   group.long 0x34--0x37 "QMEMBIST_FAILED0 (at 0x80020034)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "QMEMBIST_FAILED1"
   group.long 0x38--0x3b "QMEMBIST_FAILED1 (at 0x80020038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "QMEMBIST_FAILED2"
   group.long 0x3c--0x3f "QMEMBIST_FAILED2 (at 0x8002003c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
  tree "QMEMBIST_FAILED3"
   group.long 0x40--0x43 "QMEMBIST_FAILED3 (at 0x80020040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_RAM_FAILED                 = "
  tree.end
 tree.end
  tree "QMEMBIST_RAM_FAIL_MAP"
   group.long 0x44--0x47 "QMEMBIST_RAM_FAIL_MAP (at 0x80020044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   RAM_FAILED                     = "
  tree.end
 tree "QMEMBIST_CLKOFFm"
  tree "QMEMBIST_CLKOFF0"
   group.long 0x48--0x4b "QMEMBIST_CLKOFF0 (at 0x80020048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF1"
   group.long 0x4c--0x4f "QMEMBIST_CLKOFF1 (at 0x8002004c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF2"
   group.long 0x50--0x53 "QMEMBIST_CLKOFF2 (at 0x80020050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
  tree "QMEMBIST_CLKOFF3"
   group.long 0x54--0x57 "QMEMBIST_CLKOFF3 (at 0x80020054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   SEQ_CLKOFF                     = "
  tree.end
 tree.end
tree.end

base ad:0x80012000
tree "RXADC_WRAPPER"
  tree "RXA2D_GPR_A1"
   group.long 0x0--0x3 "RXA2D_GPR_A1 (at 0x80012000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   Y_OUTPUT_PADS                  = " "0 (ENABLE),1 (FORCED_LOW) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   Y_CONT_TEST                    = " "0 (NORMAL),1 (TEST_ENABLED) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA_CLK_OUT                   = " "0,1 "
  tree.end
  tree "RXA2D_DDO"
   group.long 0x4--0x7 "RXA2D_DDO (at 0x80012004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DDO_YI_1                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   DDO_Y1I_0                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DDO_Y2I_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   DDO_Y2I_0                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   DDO_Y1Q_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   DDO_Y1Q_0                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   DDO_Y2Q_1                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DDO_Y2Q_0                      = " "0,1 "
  tree.end
  tree "RXA2D_EN"
   group.long 0x8--0xb "RXA2D_EN (at 0x80012008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SWITCHED_CAP_BIAS              = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DEL_SIG_I_TOP                  = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DEL_SIG_I_BOT                  = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DEL_SIG_Q_TOP                  = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   DEL_SIG_Q_BOT                  = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENTIRE_A2D                     = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "RXA2D_CONF"
   group.long 0xc--0xf "RXA2D_CONF (at 0x8001200c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DATA_VALID                     = " "0 (FALLING_EDGE),1 (RISING_EDGE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   CLK_TXS_A2D                    = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DAC_REF_SEL                    = "
  tree.end
  tree "RXA2D_CLK"
   group.long 0x10--0x13 "RXA2D_CLK (at 0x80012010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   DEM_ERR_DET                    = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   TOP_DEM                        = " "0 (NORMAL_OPERATION),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   BOT_DEM                        = " "0 (NORMAL_OPERATION),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   LO_CLK_PD_EN                   = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   CLK_SOURCE                     = " "0 (LO),1 (FROM_MSM) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_DIV_SEL                    = " "0 (DIV1),1 (DIV2),2 (reserved),3 (DIV4) "
  tree.end
  tree "RXA2D_CLK_HDRV"
   group.long 0x14--0x17 "RXA2D_CLK_HDRV (at 0x80012014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   C2_DB                          = " "0 (LOW_DRIVE),1 (HI_DRIVE) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   C2_D                           = " "0 (LOW_DRIVE),1 (HI_DRIVE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   C2                             = " "0 (LOW_DRIVE),1 (HDRIVE) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   C2_A                           = " "0 (LOW_DRIVE),1 (HDRIVE) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   C1_DB                          = " "0 (LOW_DRIVE),1 (HDRIVE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   C1_D                           = " "0 (LOW_DRIVE),1 (HDRIVE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   C1                             = " "0 (LOW_DRIVE),1 (HDRIVE) "
  tree.end
  tree "RXA2D_CM1"
   group.long 0x18--0x1b "RXA2D_CM1 (at 0x80012018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   DAC_LPF_BW                     = " "0 (NOMINAL),1 (FAST_RESERVED) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VOCM_SEL                       = " "0 (1_2V),1 (1_25V),2 (1_3V),3 (1_15V) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VICM_SEL                       = " "0 (0_95V),1 (1_0V),2 (1_05V),3 (0_9V) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   VOCM_BYP_CAP                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   VICM_BYP_CAP                   = " "0 (ENABLE),1 (DISABLE) "
  tree.end
  tree "RXA2D_BOOST"
   group.long 0x1c--0x1f "RXA2D_BOOST (at 0x8001201c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BOOST_PWD                      = " "0 (1NS),1 (0_65NS),2 (1_25NS),3 (1_5NS) "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   BOOST_AMP                      = " "0 (1_6MA),1 (2MA),2 (1_33MA),3 (1_0MA) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BOOST_EN                       = " "0 (ENABLE),1 (DISABLE) "
  tree.end
  tree "RXA2D_I1"
   group.long 0x20--0x23 "RXA2D_I1 (at 0x80012020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DAC_CUR_COMP                   = " "0 (reserved),1 (reserved),2 (reserved),3 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREF_GEN_CUR                   = " "0 (100UA),1 (200UA),2 (300UA),3 (400UA) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MSTR_BIAS_CTL                  = "
  tree.end
  tree "RXA2D_I2"
   group.long 0x24--0x27 "RXA2D_I2 (at 0x80012024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OTA_CUR_1                      = " "0 (NOM),1 (5_4X),2 (1_2X),3 (3_4X) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OTA_CUR_2                      = " "0 (NOM),1 (5_4X),2 (1_2X),3 (3_4X) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OTA_CUR_3                      = " "0 (NOM),1 (5_4X),2 (1_2X),3 (3_4X) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTA_CUR_4                      = " "0 (NOM),1 (5_4X),2 (1_2X),3 (3_4X) "
  tree.end
  tree "RXA2D_I3"
   group.long 0x28--0x2b "RXA2D_I3 (at 0x80012028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   COMP_CUR                       = " "0 (NOM),1 (2X),2 (0_5X),3 (1_5X) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VICM_BUF_CUR                   = " "0 (50UA),1 (100UA),2 (200UA),3 (400UA) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOCM_BUF_CUR                   = " "0 (50UA),1 (100UA),2 (200UA),3 (400UA) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   DAC_OTA_CUR                    = " "0 (NOMINAL),1 (2X) "
  tree.end
  tree "RXA2D_TMUX"
   group.long 0x2c--0x2f "RXA2D_TMUX (at 0x8001202c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST_1_SEL                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_2_SEL                    = "
  tree.end
  tree "RXA2D_CMP"
   group.long 0x30--0x33 "RXA2D_CMP (at 0x80012030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   COMP_REF_UPP                   = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   COMP_REF_LOW                   = "
  tree.end
  tree "RXA2D_AAF"
   group.long 0x34--0x37 "RXA2D_AAF (at 0x80012034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   AAF_IP_TO_ATEST                = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   AAF_OP_TO_ATEST                = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ADC_IP_TO_CM                   = " "0 (DISABLE),1 (ENABLE) "
  tree.end
tree.end
tree "RXF"
base ad:0x90000200
tree "RXF_AGC"
 tree "RX_AGCc_RESET"
  tree "RX_AGC0_RESET"
   group.long 0x0--0x3 "RX_AGC0_RESET (at 0x90000200) "
    line.long 0x0 "VALUE"
  tree.end
  tree "RX_AGC1_RESET"
   group.long 0x100--0x103 "RX_AGC1_RESET (at 0x90000300)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_RESET to read/write)"
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "RX_AGCc_MODE_SEL"
  tree "RX_AGC0_MODE_SEL"
   group.long 0x4--0x7 "RX_AGC0_MODE_SEL (at 0x90000204)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_MODE_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AGC_MODE                       = " "0 (INACTIVE),1 (CDMA_1X_GPS_MODE),2 (HDR_HLC_MODE),3 (HDR_FLC_MODE) "
  tree.end
  tree "RX_AGC1_MODE_SEL"
   group.long 0x104--0x107 "RX_AGC1_MODE_SEL (at 0x90000304)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_MODE_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AGC_MODE                       = " "0 (INACTIVE),1 (CDMA_1X_GPS_MODE),2 (HDR_HLC_MODE),3 (HDR_FLC_MODE) "
  tree.end
 tree.end
 tree "RX_AGCc_LGLUT_LVAL"
  tree "RX_AGC0_LGLUT_LVAL"
   group.long 0x8--0xb "RX_AGC0_LGLUT_LVAL (at 0x90000208)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LGLUT_LVAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   LOOP_GAIN_LUT_7                = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   LOOP_GAIN_LUT_6                = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LOOP_GAIN_LUT_5                = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LOOP_GAIN_LUT_4                = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOOP_GAIN_LUT_3                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   LOOP_GAIN_LUT_2                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOOP_GAIN_LUT_1                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_GAIN_LUT_0                = "
  tree.end
  tree "RX_AGC1_LGLUT_LVAL"
   group.long 0x108--0x10b "RX_AGC1_LGLUT_LVAL (at 0x90000308)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LGLUT_LVAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   LOOP_GAIN_LUT_7                = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   LOOP_GAIN_LUT_6                = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LOOP_GAIN_LUT_5                = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LOOP_GAIN_LUT_4                = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOOP_GAIN_LUT_3                = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   LOOP_GAIN_LUT_2                = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOOP_GAIN_LUT_1                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_GAIN_LUT_0                = "
  tree.end
 tree.end
 tree "RX_AGCc_LGLUT_HVAL"
  tree "RX_AGC0_LGLUT_HVAL"
   group.long 0xc--0xf "RX_AGC0_LGLUT_HVAL (at 0x9000020c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LGLUT_HVAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   LOOP_GAIN_LUT_15               = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   LOOP_GAIN_LUT_14               = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LOOP_GAIN_LUT_13               = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LOOP_GAIN_LUT_12               = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOOP_GAIN_LUT_11               = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   LOOP_GAIN_LUT_10               = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOOP_GAIN_LUT_9                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_GAIN_LUT_8                = "
  tree.end
  tree "RX_AGC1_LGLUT_HVAL"
   group.long 0x10c--0x10f "RX_AGC1_LGLUT_HVAL (at 0x9000030c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LGLUT_HVAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   LOOP_GAIN_LUT_15               = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   LOOP_GAIN_LUT_14               = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   LOOP_GAIN_LUT_13               = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   LOOP_GAIN_LUT_12               = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   LOOP_GAIN_LUT_11               = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   LOOP_GAIN_LUT_10               = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOOP_GAIN_LUT_9                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_GAIN_LUT_8                = "
  tree.end
 tree.end
 tree "RX_AGCc_GAIN_CTL"
  tree "RX_AGC0_GAIN_CTL"
   group.long 0x10--0x13 "RX_AGC0_GAIN_CTL (at 0x90000210)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_GAIN_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   GAIN_CONSTANT_IM               = " "0 (USE_GAIN_CONSTANT_VALUE),1 (196),2 (98),3 (73) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GAIN_CONSTANT                  = "
  tree.end
  tree "RX_AGC1_GAIN_CTL"
   group.long 0x110--0x113 "RX_AGC1_GAIN_CTL (at 0x90000310)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_GAIN_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   GAIN_CONSTANT_IM               = " "0 (USE_GAIN_CONSTANT_VALUE),1 (196),2 (98),3 (73) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GAIN_CONSTANT                  = "
  tree.end
 tree.end
 tree "RX_AGCc_LNA_CTL"
  tree "RX_AGC0_LNA_CTL"
   group.long 0x14--0x17 "RX_AGC0_LNA_CTL (at 0x90000214)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   LNA_RANGE_OVERRIDE_N           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LNA_DECISION_OVERRIDE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   LNA_RANGE_FILT_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   AGC_VALUE_OVERRIDE             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   LNA_FILT_OVERRIDE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LNA_FILT_BW                    = " "0 (1_6_MS),1 (3_3_MS),2 (6_7_MS),3 (13_3_MS) "
  tree.end
  tree "RX_AGC1_LNA_CTL"
   group.long 0x114--0x117 "RX_AGC1_LNA_CTL (at 0x90000314)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   LNA_RANGE_OVERRIDE_N           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LNA_DECISION_OVERRIDE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   LNA_RANGE_FILT_SEL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   AGC_VALUE_OVERRIDE             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   LNA_FILT_OVERRIDE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LNA_FILT_BW                    = " "0 (1_6_MS),1 (3_3_MS),2 (6_7_MS),3 (13_3_MS) "
  tree.end
 tree.end
 tree "RX_AGCc_LNA_DATA"
  tree "RX_AGC0_LNA_DATA"
   group.long 0x18--0x1b "RX_AGC0_LNA_DATA (at 0x90000218)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   LNA_RANGE                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LNA_DECISION                   = "
  tree.end
  tree "RX_AGC1_LNA_DATA"
   group.long 0x118--0x11b "RX_AGC1_LNA_DATA (at 0x90000318)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   LNA_RANGE                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LNA_DECISION                   = "
  tree.end
 tree.end
 tree "RX_AGCc_VALUE_WR"
  tree "RX_AGC0_VALUE_WR"
   group.long 0x1c--0x1f "RX_AGC0_VALUE_WR (at 0x9000021c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_VALUE_WR"
   group.long 0x11c--0x11f "RX_AGC1_VALUE_WR (at 0x9000031c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_LNA_FILT_WR"
  tree "RX_AGC0_LNA_FILT_WR"
   group.long 0x20--0x23 "RX_AGC0_LNA_FILT_WR (at 0x90000220)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_FILT_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_FILT_WR"
   group.long 0x120--0x123 "RX_AGC1_LNA_FILT_WR (at 0x90000320)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_FILT_WR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_DC_GAIN"
  tree "RX_AGC0_DC_GAIN"
   group.long 0x24--0x27 "RX_AGC0_DC_GAIN (at 0x90000224)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_DC_GAIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AGC_VALUE_MIN_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   AGC_LOOP_FREEZE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   AGC_DC_GAIN_EN                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AGC_DC_GAIN_VAL                = "
  tree.end
  tree "RX_AGC1_DC_GAIN"
   group.long 0x124--0x127 "RX_AGC1_DC_GAIN (at 0x90000324)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_DC_GAIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   AGC_VALUE_MIN_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   AGC_LOOP_FREEZE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   AGC_DC_GAIN_EN                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AGC_DC_GAIN_VAL                = "
  tree.end
 tree.end
 tree "RX_AGCc_VALUE_n_MIN"
 tree "RX_AGC0_VALUE_n_MIN"
  tree "RX_AGC0_VALUE_1_MIN"
   group.long 0x28--0x2b "RX_AGC0_VALUE_1_MIN (at 0x90000228)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_1_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_VALUE_2_MIN"
   group.long 0x2c--0x2f "RX_AGC0_VALUE_2_MIN (at 0x9000022c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_2_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_VALUE_3_MIN"
   group.long 0x30--0x33 "RX_AGC0_VALUE_3_MIN (at 0x90000230)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_3_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_VALUE_4_MIN"
   group.long 0x34--0x37 "RX_AGC0_VALUE_4_MIN (at 0x90000234)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_4_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_VALUE_n_MIN"
  tree "RX_AGC1_VALUE_1_MIN"
   group.long 0x28--0x2b "RX_AGC1_VALUE_1_MIN (at 0x90000228)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_1_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_VALUE_2_MIN"
   group.long 0x2c--0x2f "RX_AGC1_VALUE_2_MIN (at 0x9000022c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_2_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_VALUE_3_MIN"
   group.long 0x30--0x33 "RX_AGC1_VALUE_3_MIN (at 0x90000230)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_3_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_VALUE_4_MIN"
   group.long 0x34--0x37 "RX_AGC1_VALUE_4_MIN (at 0x90000234)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_4_MIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_VALUE_MAX"
  tree "RX_AGC0_VALUE_MAX"
   group.long 0x38--0x3b "RX_AGC0_VALUE_MAX (at 0x90000238)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VALUE_MAX to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   AGC_VALUE_MAX_EN               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   AGC_VALUE_MAX                  = "
  tree.end
  tree "RX_AGC1_VALUE_MAX"
   group.long 0x138--0x13b "RX_AGC1_VALUE_MAX (at 0x90000338)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VALUE_MAX to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   AGC_VALUE_MAX_EN               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   AGC_VALUE_MAX                  = "
  tree.end
 tree.end
 tree "RX_AGCc_IM_LEVELn"
 tree "RX_AGC0_IM_LEVELn"
  tree "RX_AGC0_IM_LEVEL1"
   group.long 0x3c--0x3f "RX_AGC0_IM_LEVEL1 (at 0x9000023c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_IM_LEVEL1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_IM_LEVEL2"
   group.long 0x40--0x43 "RX_AGC0_IM_LEVEL2 (at 0x90000240)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_IM_LEVEL2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_IM_LEVEL3"
   group.long 0x44--0x47 "RX_AGC0_IM_LEVEL3 (at 0x90000244)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_IM_LEVEL3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_IM_LEVEL4"
   group.long 0x48--0x4b "RX_AGC0_IM_LEVEL4 (at 0x90000248)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_IM_LEVEL4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_IM_LEVELn"
  tree "RX_AGC1_IM_LEVEL1"
   group.long 0x3c--0x3f "RX_AGC1_IM_LEVEL1 (at 0x9000023c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_IM_LEVEL1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_IM_LEVEL2"
   group.long 0x40--0x43 "RX_AGC1_IM_LEVEL2 (at 0x90000240)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_IM_LEVEL2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_IM_LEVEL3"
   group.long 0x44--0x47 "RX_AGC1_IM_LEVEL3 (at 0x90000244)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_IM_LEVEL3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_IM_LEVEL4"
   group.long 0x48--0x4b "RX_AGC1_IM_LEVEL4 (at 0x90000248)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_IM_LEVEL4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_n_FALL"
 tree "RX_AGC0_LNA_n_FALL"
  tree "RX_AGC0_LNA_1_FALL"
   group.long 0x4c--0x4f "RX_AGC0_LNA_1_FALL (at 0x9000024c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_1_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_2_FALL"
   group.long 0x50--0x53 "RX_AGC0_LNA_2_FALL (at 0x90000250)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_2_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_3_FALL"
   group.long 0x54--0x57 "RX_AGC0_LNA_3_FALL (at 0x90000254)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_3_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_4_FALL"
   group.long 0x58--0x5b "RX_AGC0_LNA_4_FALL (at 0x90000258)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_4_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_LNA_n_FALL"
  tree "RX_AGC1_LNA_1_FALL"
   group.long 0x4c--0x4f "RX_AGC1_LNA_1_FALL (at 0x9000024c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_1_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_2_FALL"
   group.long 0x50--0x53 "RX_AGC1_LNA_2_FALL (at 0x90000250)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_2_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_3_FALL"
   group.long 0x54--0x57 "RX_AGC1_LNA_3_FALL (at 0x90000254)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_3_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_4_FALL"
   group.long 0x58--0x5b "RX_AGC1_LNA_4_FALL (at 0x90000258)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_4_FALL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_n_RISE"
 tree "RX_AGC0_LNA_n_RISE"
  tree "RX_AGC0_LNA_1_RISE"
   group.long 0x5c--0x5f "RX_AGC0_LNA_1_RISE (at 0x9000025c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_1_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_2_RISE"
   group.long 0x60--0x63 "RX_AGC0_LNA_2_RISE (at 0x90000260)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_2_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_3_RISE"
   group.long 0x64--0x67 "RX_AGC0_LNA_3_RISE (at 0x90000264)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_3_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_4_RISE"
   group.long 0x68--0x6b "RX_AGC0_LNA_4_RISE (at 0x90000268)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_4_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_LNA_n_RISE"
  tree "RX_AGC1_LNA_1_RISE"
   group.long 0x5c--0x5f "RX_AGC1_LNA_1_RISE (at 0x9000025c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_1_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_2_RISE"
   group.long 0x60--0x63 "RX_AGC1_LNA_2_RISE (at 0x90000260)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_2_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_3_RISE"
   group.long 0x64--0x67 "RX_AGC1_LNA_3_RISE (at 0x90000264)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_3_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_4_RISE"
   group.long 0x68--0x6b "RX_AGC1_LNA_4_RISE (at 0x90000268)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_4_RISE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_n_OFFSET"
 tree "RX_AGC0_LNA_n_OFFSET"
  tree "RX_AGC0_LNA_1_OFFSET"
   group.long 0x6c--0x6f "RX_AGC0_LNA_1_OFFSET (at 0x9000026c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_1_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_2_OFFSET"
   group.long 0x70--0x73 "RX_AGC0_LNA_2_OFFSET (at 0x90000270)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_2_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_3_OFFSET"
   group.long 0x74--0x77 "RX_AGC0_LNA_3_OFFSET (at 0x90000274)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_3_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_4_OFFSET"
   group.long 0x78--0x7b "RX_AGC0_LNA_4_OFFSET (at 0x90000278)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_4_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_LNA_n_OFFSET"
  tree "RX_AGC1_LNA_1_OFFSET"
   group.long 0x6c--0x6f "RX_AGC1_LNA_1_OFFSET (at 0x9000026c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_1_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_2_OFFSET"
   group.long 0x70--0x73 "RX_AGC1_LNA_2_OFFSET (at 0x90000270)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_2_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_3_OFFSET"
   group.long 0x74--0x77 "RX_AGC1_LNA_3_OFFSET (at 0x90000274)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_3_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_4_OFFSET"
   group.long 0x78--0x7b "RX_AGC1_LNA_4_OFFSET (at 0x90000278)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_4_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_BP_TIMER_n"
 tree "RX_AGC0_LNA_BP_TIMER_n"
  tree "RX_AGC0_LNA_BP_TIMER_0"
   group.long 0x7c--0x7f "RX_AGC0_LNA_BP_TIMER_0 (at 0x9000027c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_BP_TIMER_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_BP_TIMER_1"
   group.long 0x80--0x83 "RX_AGC0_LNA_BP_TIMER_1 (at 0x90000280)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_BP_TIMER_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_BP_TIMER_2"
   group.long 0x84--0x87 "RX_AGC0_LNA_BP_TIMER_2 (at 0x90000284)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_BP_TIMER_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_BP_TIMER_3"
   group.long 0x88--0x8b "RX_AGC0_LNA_BP_TIMER_3 (at 0x90000288)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_BP_TIMER_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_LNA_BP_TIMER_n"
  tree "RX_AGC1_LNA_BP_TIMER_0"
   group.long 0x7c--0x7f "RX_AGC1_LNA_BP_TIMER_0 (at 0x9000027c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_BP_TIMER_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_BP_TIMER_1"
   group.long 0x80--0x83 "RX_AGC1_LNA_BP_TIMER_1 (at 0x90000280)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_BP_TIMER_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_BP_TIMER_2"
   group.long 0x84--0x87 "RX_AGC1_LNA_BP_TIMER_2 (at 0x90000284)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_BP_TIMER_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_BP_TIMER_3"
   group.long 0x88--0x8b "RX_AGC1_LNA_BP_TIMER_3 (at 0x90000288)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_BP_TIMER_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_NBP_TIMER_n"
 tree "RX_AGC0_LNA_NBP_TIMER_n"
  tree "RX_AGC0_LNA_NBP_TIMER_0"
   group.long 0x8c--0x8f "RX_AGC0_LNA_NBP_TIMER_0 (at 0x9000028c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_NBP_TIMER_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_NBP_TIMER_1"
   group.long 0x90--0x93 "RX_AGC0_LNA_NBP_TIMER_1 (at 0x90000290)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_NBP_TIMER_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_NBP_TIMER_2"
   group.long 0x94--0x97 "RX_AGC0_LNA_NBP_TIMER_2 (at 0x90000294)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_NBP_TIMER_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC0_LNA_NBP_TIMER_3"
   group.long 0x98--0x9b "RX_AGC0_LNA_NBP_TIMER_3 (at 0x90000298)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_NBP_TIMER_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGC1_LNA_NBP_TIMER_n"
  tree "RX_AGC1_LNA_NBP_TIMER_0"
   group.long 0x8c--0x8f "RX_AGC1_LNA_NBP_TIMER_0 (at 0x9000028c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_NBP_TIMER_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_NBP_TIMER_1"
   group.long 0x90--0x93 "RX_AGC1_LNA_NBP_TIMER_1 (at 0x90000290)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_NBP_TIMER_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_NBP_TIMER_2"
   group.long 0x94--0x97 "RX_AGC1_LNA_NBP_TIMER_2 (at 0x90000294)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_NBP_TIMER_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_NBP_TIMER_3"
   group.long 0x98--0x9b "RX_AGC1_LNA_NBP_TIMER_3 (at 0x90000298)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_NBP_TIMER_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DATA                           = "
  tree.end
 tree.end
 tree.end
 tree "RX_AGCc_LNA_RANGE_DELAY"
  tree "RX_AGC0_LNA_RANGE_DELAY"
   group.long 0x9c--0x9f "RX_AGC0_LNA_RANGE_DELAY (at 0x9000029c)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_LNA_RANGE_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_RANGE_DELAY"
   group.long 0x19c--0x19f "RX_AGC1_LNA_RANGE_DELAY (at 0x9000039c)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_LNA_RANGE_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_SBI_CTL"
  tree "RX_AGC0_SBI_CTL"
   group.long 0xa0--0xa3 "RX_AGC0_SBI_CTL (at 0x900002a0)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_SBI_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   AGC_SBI_LNA_RANGE              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AGC_SBI_LNA_OVERRIDE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AGC_SBI_BYPASS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   AGC_SBI_EN                     = " "0,1 "
  tree.end
  tree "RX_AGC1_SBI_CTL"
   group.long 0x1a0--0x1a3 "RX_AGC1_SBI_CTL (at 0x900003a0)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_SBI_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   AGC_SBI_LNA_RANGE              = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   AGC_SBI_LNA_OVERRIDE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AGC_SBI_BYPASS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   AGC_SBI_EN                     = " "0,1 "
  tree.end
 tree.end
 tree "RX_AGCc_SBI_ID"
  tree "RX_AGC0_SBI_ID"
   group.long 0xa4--0xa7 "RX_AGC0_SBI_ID (at 0x900002a4)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_SBI_ID to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_ID                         = "
  tree.end
  tree "RX_AGC1_SBI_ID"
   group.long 0x1a4--0x1a7 "RX_AGC1_SBI_ID (at 0x900003a4)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_SBI_ID to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_ID                         = "
  tree.end
 tree.end
 tree "RX_AGCc_SBI_ADDR"
  tree "RX_AGC0_SBI_ADDR"
   group.long 0xa8--0xab "RX_AGC0_SBI_ADDR (at 0x900002a8)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_SBI_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_ADDR                       = "
  tree.end
  tree "RX_AGC1_SBI_ADDR"
   group.long 0x1a8--0x1ab "RX_AGC1_SBI_ADDR (at 0x900003a8)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_SBI_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_ADDR                       = "
  tree.end
 tree.end
 tree "RX_AGCc_SBI_DATA0"
  tree "RX_AGC0_SBI_DATA0"
   group.long 0xac--0xaf "RX_AGC0_SBI_DATA0 (at 0x900002ac)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_SBI_DATA0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   SBI_DATA_3                     = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   SBI_DATA_2                     = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SBI_DATA_1                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_DATA_0                     = "
  tree.end
  tree "RX_AGC1_SBI_DATA0"
   group.long 0x1ac--0x1af "RX_AGC1_SBI_DATA0 (at 0x900003ac)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_SBI_DATA0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   SBI_DATA_3                     = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   SBI_DATA_2                     = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SBI_DATA_1                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_DATA_0                     = "
  tree.end
 tree.end
 tree "RX_AGCc_SBI_DATA1"
  tree "RX_AGC0_SBI_DATA1"
   group.long 0xb0--0xb3 "RX_AGC0_SBI_DATA1 (at 0x900002b0)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_SBI_DATA1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_DATA_4                     = "
  tree.end
  tree "RX_AGC1_SBI_DATA1"
   group.long 0x1b0--0x1b3 "RX_AGC1_SBI_DATA1 (at 0x900003b0)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_SBI_DATA1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SBI_DATA_4                     = "
  tree.end
 tree.end
 tree "RX_AGCc_VREF_DELAY_TIMER"
  tree "RX_AGC0_VREF_DELAY_TIMER"
   group.long 0xb4--0xb7 "RX_AGC0_VREF_DELAY_TIMER (at 0x900002b4)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VREF_DELAY_TIMER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_VREF_DELAY_TIMER"
   group.long 0x1b4--0x1b7 "RX_AGC1_VREF_DELAY_TIMER (at 0x900003b4)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VREF_DELAY_TIMER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_VREF_VAL"
  tree "RX_AGC0_VREF_VAL"
   group.long 0xb8--0xbb "RX_AGC0_VREF_VAL (at 0x900002b8)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_VREF_VAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   VREF_VAL_4                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   VREF_VAL_3                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_VAL_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   VREF_VAL_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VREF_VAL_0                     = " "0,1 "
  tree.end
  tree "RX_AGC1_VREF_VAL"
   group.long 0x1b8--0x1bb "RX_AGC1_VREF_VAL (at 0x900003b8)   (shadowed - Use hwio_shadow_ptr->RX_AGC1_VREF_VAL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   VREF_VAL_4                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   VREF_VAL_3                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_VAL_2                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   VREF_VAL_1                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VREF_VAL_0                     = " "0,1 "
  tree.end
 tree.end
 tree "RX_AGCc_TEST_CTL"
  tree "RX_AGC0_TEST_CTL"
   group.long 0xbc--0xbf "RX_AGC0_TEST_CTL (at 0x900002bc)   (shadowed - Use hwio_shadow_ptr->RX_AGC0_TEST_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AGC_BET_ENABLE                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTEGRATOR_BYPASS              = " "0,1 "
  tree.end
  tree "RX_AGC1_TEST_CTL"
   group.long 0x1bc--0x1bf "RX_AGC1_TEST_CTL (at 0x900003bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AGC_BET_ENABLE                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   INTEGRATOR_BYPASS              = " "0,1 "
  tree.end
 tree.end
 tree "RX_AGCc_1X_VALUE_RD"
  tree "RX_AGC0_1X_VALUE_RD"
   group.long 0xc0--0xc3 "RX_AGC0_1X_VALUE_RD (at 0x900002c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_1X_VALUE_RD"
   group.long 0x1c0--0x1c3 "RX_AGC1_1X_VALUE_RD (at 0x900003c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_HDR_VALUE_RD"
  tree "RX_AGC0_HDR_VALUE_RD"
   group.long 0xc4--0xc7 "RX_AGC0_HDR_VALUE_RD (at 0x900002c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_HDR_VALUE_RD"
   group.long 0x1c4--0x1c7 "RX_AGC1_HDR_VALUE_RD (at 0x900003c4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_1X_VGA_GAIN_RD"
  tree "RX_AGC0_1X_VGA_GAIN_RD"
   group.long 0xc8--0xcb "RX_AGC0_1X_VGA_GAIN_RD (at 0x900002c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_1X_VGA_GAIN_RD"
   group.long 0x1c8--0x1cb "RX_AGC1_1X_VGA_GAIN_RD (at 0x900003c8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_HDR_VGA_GAIN_RD"
  tree "RX_AGC0_HDR_VGA_GAIN_RD"
   group.long 0xcc--0xcf "RX_AGC0_HDR_VGA_GAIN_RD (at 0x900002cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_HDR_VGA_GAIN_RD"
   group.long 0x1cc--0x1cf "RX_AGC1_HDR_VGA_GAIN_RD (at 0x900003cc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_LNA_FILT_RD"
  tree "RX_AGC0_LNA_FILT_RD"
   group.long 0xd0--0xd3 "RX_AGC0_LNA_FILT_RD (at 0x900002d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
  tree "RX_AGC1_LNA_FILT_RD"
   group.long 0x1d0--0x1d3 "RX_AGC1_LNA_FILT_RD (at 0x900003d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RX_AGCc_LNA_RANGE_RD"
  tree "RX_AGC0_LNA_RANGE_RD"
   group.long 0xd4--0xd7 "RX_AGC0_LNA_RANGE_RD (at 0x900002d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                           = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "RX_AGC1_LNA_RANGE_RD"
   group.long 0x1d4--0x1d7 "RX_AGC1_LNA_RANGE_RD (at 0x900003d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                           = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
tree.end

base ad:0x90003600
tree "RXF_SRC_RF"
 tree "RXF_SRCc_RESET"
  tree "RXF_SRC0_RESET"
   group.long 0x0--0x3 "RXF_SRC0_RESET (at 0x90003600)   (shadowed - Use hwio_shadow_ptr->RXF_SRC0_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SW_RESET                       = " "0,1 "
  tree.end
  tree "RXF_SRC1_RESET"
   group.long 0x80--0x83 "RXF_SRC1_RESET (at 0x90003680) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SW_RESET                       = " "0,1 "
  tree.end
 tree.end
 tree "RXF_SRCc_CTL"
  tree "RXF_SRC0_CTL"
   group.long 0x4--0x7 "RXF_SRC0_CTL (at 0x90003604) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   FS_CLK_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CXN_CLK_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPECTRAL_INVERSION             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   USE_RTC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   BYPASS_IMC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYPASS_MIS_COMP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   BYPASS_DCC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EC_Y2_SCALE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GREY_MAP_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BBF_BYPASS                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   ALT_SRC_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   BYPASS_SRC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   CHIPX8_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   BYPASS_RXF                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   TEST_MODE                      = " "0 (Y1_AND_Y2_INPUTS_FROM_RAMBO),1 (SELECT_INPUT_FORM_TEST_BUS) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   BYPASS_CORDIC                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   ROT_PHACC_CLR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ROT_TEST_MODE                  = " "0 (NORMAL_OPERATING_MODE),1 (SET_ROTATOR_S_INPUT_TO_ZERO),2 (SET_ROTATOR_S_INPUT_TO_5555),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BYPASS_DVGA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MICRO_GAIN_OVERRIDE_N          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RXF_TEST_MODE                  = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   GRP_DELAY_ADJ                  = "
  tree.end
  tree "RXF_SRC1_CTL"
   group.long 0x84--0x87 "RXF_SRC1_CTL (at 0x90003684) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   FS_CLK_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   CXN_CLK_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   SPECTRAL_INVERSION             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   USE_RTC                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   BYPASS_IMC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   BYPASS_MIS_COMP                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   BYPASS_DCC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   EC_Y2_SCALE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   GREY_MAP_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   BBF_BYPASS                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   ALT_SRC_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   BYPASS_SRC                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   CHIPX8_INV                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   BYPASS_RXF                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   TEST_MODE                      = " "0 (Y1_AND_Y2_INPUTS_FROM_RAMBO),1 (SELECT_INPUT_FORM_TEST_BUS) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   BYPASS_CORDIC                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   ROT_PHACC_CLR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   ROT_TEST_MODE                  = " "0 (NORMAL_OPERATING_MODE),1 (SET_ROTATOR_S_INPUT_TO_ZERO),2 (SET_ROTATOR_S_INPUT_TO_5555),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   BYPASS_DVGA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MICRO_GAIN_OVERRIDE_N          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RXF_TEST_MODE                  = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   GRP_DELAY_ADJ                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_PHASE_DEL"
  tree "RXF_SRC0_PHASE_DEL"
   group.long 0x8--0xb "RXF_SRC0_PHASE_DEL (at 0x90003608) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   RXF_PHASE_SEL_DELAY            = "
  tree.end
  tree "RXF_SRC1_PHASE_DEL"
   group.long 0x88--0x8b "RXF_SRC1_PHASE_DEL (at 0x90003688) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   RXF_PHASE_SEL_DELAY            = "
  tree.end
 tree.end
 tree "RXF_SRCc_LNA_S0_PHASE_OFFSET"
  tree "RXF_SRC0_LNA_S0_PHASE_OFFSET"
   group.long 0xc--0xf "RXF_SRC0_LNA_S0_PHASE_OFFSET (at 0x9000360c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S0_PHASE_OFFSET            = "
  tree.end
  tree "RXF_SRC1_LNA_S0_PHASE_OFFSET"
   group.long 0x8c--0x8f "RXF_SRC1_LNA_S0_PHASE_OFFSET (at 0x9000368c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S0_PHASE_OFFSET            = "
  tree.end
 tree.end
 tree "RXF_SRCc_LNA_S1_PHASE_OFFSET"
  tree "RXF_SRC0_LNA_S1_PHASE_OFFSET"
   group.long 0x10--0x13 "RXF_SRC0_LNA_S1_PHASE_OFFSET (at 0x90003610) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S1_PHASE_OFFSET            = "
  tree.end
  tree "RXF_SRC1_LNA_S1_PHASE_OFFSET"
   group.long 0x90--0x93 "RXF_SRC1_LNA_S1_PHASE_OFFSET (at 0x90003690) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S1_PHASE_OFFSET            = "
  tree.end
 tree.end
 tree "RXF_SRCc_LNA_S2_PHASE_OFFSET"
  tree "RXF_SRC0_LNA_S2_PHASE_OFFSET"
   group.long 0x14--0x17 "RXF_SRC0_LNA_S2_PHASE_OFFSET (at 0x90003614) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S2_PHASE_OFFSET            = "
  tree.end
  tree "RXF_SRC1_LNA_S2_PHASE_OFFSET"
   group.long 0x94--0x97 "RXF_SRC1_LNA_S2_PHASE_OFFSET (at 0x90003694) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S2_PHASE_OFFSET            = "
  tree.end
 tree.end
 tree "RXF_SRCc_LNA_S3_PHASE_OFFSET"
  tree "RXF_SRC0_LNA_S3_PHASE_OFFSET"
   group.long 0x18--0x1b "RXF_SRC0_LNA_S3_PHASE_OFFSET (at 0x90003618) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S3_PHASE_OFFSET            = "
  tree.end
  tree "RXF_SRC1_LNA_S3_PHASE_OFFSET"
   group.long 0x98--0x9b "RXF_SRC1_LNA_S3_PHASE_OFFSET (at 0x90003698) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S3_PHASE_OFFSET            = "
  tree.end
 tree.end
 tree "RXF_SRCc_LNA_S4_PHASE_OFFSET"
  tree "RXF_SRC0_LNA_S4_PHASE_OFFSET"
   group.long 0x1c--0x1f "RXF_SRC0_LNA_S4_PHASE_OFFSET (at 0x9000361c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S4_PHASE_OFFSET            = "
  tree.end
  tree "RXF_SRC1_LNA_S4_PHASE_OFFSET"
   group.long 0x9c--0x9f "RXF_SRC1_LNA_S4_PHASE_OFFSET (at 0x9000369c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LNA_S4_PHASE_OFFSET            = "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_NOTCH0_PARAMS"
  tree "RXF_SRC0_BBF_NOTCH0_PARAMS"
   group.long 0x24--0x27 "RXF_SRC0_BBF_NOTCH0_PARAMS (at 0x90003624) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "RXF_SRC1_BBF_NOTCH0_PARAMS"
   group.long 0xa4--0xa7 "RXF_SRC1_BBF_NOTCH0_PARAMS (at 0x900036a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_NOTCH1_PARAMS"
  tree "RXF_SRC0_BBF_NOTCH1_PARAMS"
   group.long 0x28--0x2b "RXF_SRC0_BBF_NOTCH1_PARAMS (at 0x90003628) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "RXF_SRC1_BBF_NOTCH1_PARAMS"
   group.long 0xa8--0xab "RXF_SRC1_BBF_NOTCH1_PARAMS (at 0x900036a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_NOTCH2_PARAMS"
  tree "RXF_SRC0_BBF_NOTCH2_PARAMS"
   group.long 0x2c--0x2f "RXF_SRC0_BBF_NOTCH2_PARAMS (at 0x9000362c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "RXF_SRC1_BBF_NOTCH2_PARAMS"
   group.long 0xac--0xaf "RXF_SRC1_BBF_NOTCH2_PARAMS (at 0x900036ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1d--0x1f "  [31:29]   PWR_HYST                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.word 0x0 0x13--0x1c 1 "  [28:19]   NOTCH_PWR_REF2                 = "
    textline ""
    hexmask.long.word 0x0 0x9--0x12 1 "  [18: 9]   NOTCH_PWR_REF1                 = "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   NOTCH_NBIT2                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH_NBIT1                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH_NBIT0                    = " "0,1,2,3,4,5,6,7 "
  tree.end
 tree.end
 tree "RXF_SRCc_MIS_COMP_A_COEFF"
  tree "RXF_SRC0_MIS_COMP_A_COEFF"
   group.long 0x30--0x33 "RXF_SRC0_MIS_COMP_A_COEFF (at 0x90003630) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   DATA                           = "
  tree.end
  tree "RXF_SRC1_MIS_COMP_A_COEFF"
   group.long 0xb0--0xb3 "RXF_SRC1_MIS_COMP_A_COEFF (at 0x900036b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RXF_SRCc_MIS_COMP_B_COEFF"
  tree "RXF_SRC0_MIS_COMP_B_COEFF"
   group.long 0x34--0x37 "RXF_SRC0_MIS_COMP_B_COEFF (at 0x90003634) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   DATA                           = "
  tree.end
  tree "RXF_SRC1_MIS_COMP_B_COEFF"
   group.long 0xb4--0xb7 "RXF_SRC1_MIS_COMP_B_COEFF (at 0x900036b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   DATA                           = "
  tree.end
 tree.end
 tree "RXF_SRCc_RESAMP_PHASE_MAP0"
  tree "RXF_SRC0_RESAMP_PHASE_MAP0"
   group.long 0x38--0x3b "RXF_SRC0_RESAMP_PHASE_MAP0 (at 0x90003638) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
  tree "RXF_SRC1_RESAMP_PHASE_MAP0"
   group.long 0xb8--0xbb "RXF_SRC1_RESAMP_PHASE_MAP0 (at 0x900036b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
 tree.end
 tree "RXF_SRCc_RESAMP_PHASE_MAP1"
  tree "RXF_SRC0_RESAMP_PHASE_MAP1"
   group.long 0x3c--0x3f "RXF_SRC0_RESAMP_PHASE_MAP1 (at 0x9000363c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
  tree "RXF_SRC1_RESAMP_PHASE_MAP1"
   group.long 0xbc--0xbf "RXF_SRC1_RESAMP_PHASE_MAP1 (at 0x900036bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
 tree.end
 tree "RXF_SRCc_RESAMP_PHASE_MAP2"
  tree "RXF_SRC0_RESAMP_PHASE_MAP2"
   group.long 0x40--0x43 "RXF_SRC0_RESAMP_PHASE_MAP2 (at 0x90003640) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
  tree "RXF_SRC1_RESAMP_PHASE_MAP2"
   group.long 0xc0--0xc3 "RXF_SRC1_RESAMP_PHASE_MAP2 (at 0x900036c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
 tree.end
 tree "RXF_SRCc_RESAMP_PHASE_MAP3"
  tree "RXF_SRC0_RESAMP_PHASE_MAP3"
   group.long 0x44--0x47 "RXF_SRC0_RESAMP_PHASE_MAP3 (at 0x90003644) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
  tree "RXF_SRC1_RESAMP_PHASE_MAP3"
   group.long 0xc4--0xc7 "RXF_SRC1_RESAMP_PHASE_MAP3 (at 0x900036c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
 tree.end
 tree "RXF_SRCc_RESAMP_END_CNT"
  tree "RXF_SRC0_RESAMP_END_CNT"
   group.long 0x48--0x4b "RXF_SRC0_RESAMP_END_CNT (at 0x90003648) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   END_VAL                        = "
  tree.end
  tree "RXF_SRC1_RESAMP_END_CNT"
   group.long 0xc8--0xcb "RXF_SRC1_RESAMP_END_CNT (at 0x900036c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   END_VAL                        = "
  tree.end
 tree.end
 tree "RXF_SRCc_DVGA_PARAMS"
  tree "RXF_SRC0_DVGA_PARAMS"
   group.long 0x4c--0x4f "RXF_SRC0_DVGA_PARAMS (at 0x9000364c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   ADD_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   VGA_MODE                       = " "0 (CDMA1X_GAIN),1 (HDR_GAIN) "
    textline ""
    hexmask.long.word 0x0 0xb--0x14 1 "  [20:11]   VGA_GAIN_OFFSET                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   MICRO_VGA_GAIN                 = "
  tree.end
  tree "RXF_SRC1_DVGA_PARAMS"
   group.long 0xcc--0xcf "RXF_SRC1_DVGA_PARAMS (at 0x900036cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   ADD_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   VGA_MODE                       = " "0 (CDMA1X_GAIN),1 (HDR_GAIN) "
    textline ""
    hexmask.long.word 0x0 0xb--0x14 1 "  [20:11]   VGA_GAIN_OFFSET                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   MICRO_VGA_GAIN                 = "
  tree.end
 tree.end
 tree "RXF_SRCc_TEST_BUS_SEL"
  tree "RXF_SRC0_TEST_BUS_SEL"
   group.long 0x50--0x53 "RXF_SRC0_TEST_BUS_SEL (at 0x90003650) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RXF_TST_BUS_SEL                = "
  tree.end
  tree "RXF_SRC1_TEST_BUS_SEL"
   group.long 0xd0--0xd3 "RXF_SRC1_TEST_BUS_SEL (at 0x900036d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RXF_TST_BUS_SEL                = "
  tree.end
 tree.end
 tree "RXF_SRCc_CXN_CLK_STATUS"
  tree "RXF_SRC0_CXN_CLK_STATUS"
   group.long 0x54--0x57 "RXF_SRC0_CXN_CLK_STATUS (at 0x90003654)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   RX_SAMP_CLK_HALTED             = " "0 (RX_SAMP_CLK_IS_NOT_HALTED),1 (RX_SAMP_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CX32_CLK_HALTED                = " "0 (CX32_CLK_IS_NOT_HALTED),1 (CX32_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RX_FRONT_CLK_HALTED            = " "0 (RX_FRONT_CLK_IS_NOT_HALTED),1 (RX_FRONT_CLK_IS_HALTED) "
  tree.end
  tree "RXF_SRC1_CXN_CLK_STATUS"
   group.long 0xd4--0xd7 "RXF_SRC1_CXN_CLK_STATUS (at 0x900036d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   RX_SAMP_CLK_HALTED             = " "0 (RX_SAMP_CLK_IS_NOT_HALTED),1 (RX_SAMP_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CX32_CLK_HALTED                = " "0 (CX32_CLK_IS_NOT_HALTED),1 (CX32_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RX_FRONT_CLK_HALTED            = " "0 (RX_FRONT_CLK_IS_NOT_HALTED),1 (RX_FRONT_CLK_IS_HALTED) "
  tree.end
 tree.end
tree.end

base ad:0x90004b00
tree "RXF_SRC_RS"
 tree "RXF_SRCc_BBF_COEF0"
  tree "RXF_SRC0_BBF_COEF0"
   group.long 0x0--0x3 "RXF_SRC0_BBF_COEF0 (at 0x90004b00) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   BBF_COEF_A5                    = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x16 1 "  [22:16]   BBF_COEF_A4                    = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   BBF_COEF_A3                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   BBF_COEF_A2                    = "
  tree.end
  tree "RXF_SRC1_BBF_COEF0"
   group.long 0x100--0x103 "RXF_SRC1_BBF_COEF0 (at 0x90004c00) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   BBF_COEF_A5                    = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x16 1 "  [22:16]   BBF_COEF_A4                    = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xe 1 "  [14: 8]   BBF_COEF_A3                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   BBF_COEF_A2                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_COEF1"
  tree "RXF_SRC0_BBF_COEF1"
   group.long 0x4--0x7 "RXF_SRC0_BBF_COEF1 (at 0x90004b04) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   BBF_COEF_A7                    = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x16 1 "  [22:16]   BBF_COEF_A6                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   GREY_MAP                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   BBF_COEF_A1                    = "
  tree.end
  tree "RXF_SRC1_BBF_COEF1"
   group.long 0x104--0x107 "RXF_SRC1_BBF_COEF1 (at 0x90004c04) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   BBF_COEF_A7                    = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x16 1 "  [22:16]   BBF_COEF_A6                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   GREY_MAP                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   BBF_COEF_A1                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_COEF_NOTCH0"
  tree "RXF_SRC0_BBF_COEF_NOTCH0"
   group.long 0x8--0xb "RXF_SRC0_BBF_COEF_NOTCH0 (at 0x90004b08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
  tree "RXF_SRC1_BBF_COEF_NOTCH0"
   group.long 0x108--0x10b "RXF_SRC1_BBF_COEF_NOTCH0 (at 0x90004c08) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_COEF_NOTCH1"
  tree "RXF_SRC0_BBF_COEF_NOTCH1"
   group.long 0xc--0xf "RXF_SRC0_BBF_COEF_NOTCH1 (at 0x90004b0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
  tree "RXF_SRC1_BBF_COEF_NOTCH1"
   group.long 0x10c--0x10f "RXF_SRC1_BBF_COEF_NOTCH1 (at 0x90004c0c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
 tree.end
 tree "RXF_SRCc_BBF_COEF_NOTCH2"
  tree "RXF_SRC0_BBF_COEF_NOTCH2"
   group.long 0x10--0x13 "RXF_SRC0_BBF_COEF_NOTCH2 (at 0x90004b10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
  tree "RXF_SRC1_BBF_COEF_NOTCH2"
   group.long 0x110--0x113 "RXF_SRC1_BBF_COEF_NOTCH2 (at 0x90004c10) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BBF_COEF_ROT_I_H               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   BBF_COEF_ROT_I_L               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BBF_COEF_ROT_R_H               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BBF_COEF_ROT_R_L               = "
  tree.end
 tree.end
 tree "RXF_SRCc_OFFSET_CTL"
  tree "RXF_SRC0_OFFSET_CTL"
   group.long 0x14--0x17 "RXF_SRC0_OFFSET_CTL (at 0x90004b14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   FG_ACCUM_CLR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   FG_OFFSET_ACCUM_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   FG_ACCUM_FREQ                  = " "0 (1_8_CLK_01_1_6_CLK),1 (reserved),2 (1_4_CLK_11_1_2_CLK),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FG_ACQ_OFFSET_SCALER           = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FG_TRC_OFFSET_SCALER           = "
  tree.end
  tree "RXF_SRC1_OFFSET_CTL"
   group.long 0x114--0x117 "RXF_SRC1_OFFSET_CTL (at 0x90004c14) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   FG_ACCUM_CLR_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   FG_OFFSET_ACCUM_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   FG_ACCUM_FREQ                  = " "0 (1_8_CLK_01_1_6_CLK),1 (reserved),2 (1_4_CLK_11_1_2_CLK),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FG_ACQ_OFFSET_SCALER           = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FG_TRC_OFFSET_SCALER           = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_CTL"
  tree "RXF_SRC0_DACC_CTL"
   group.long 0x18--0x1b "RXF_SRC0_DACC_CTL (at 0x90004b18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   MICRO_DACC_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   DACC_DC_OFFSET_POLARITY        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x18 "  [24:23]   DACC_MULT_PRESCALER            = " "0 (0_25),1 (0_5),2 (1_0),3 (2_0) "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   NOT_USED                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   MICRO_MIX_RANGE_OVERIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   MICRO_LNA_RANGE_OVERIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MICRO_MIX_RANGE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   MICRO_LNA_RANGE                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   RXF_SBI_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   DACC_GCH_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DACC_PRD_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   DACC_DFT_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DACC_FG_EST_N                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   EST_ACCUM_CLR_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   EST_OFFSET_ACCUM_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   EST_ACCUM_FREQ                 = " "0 (1_8_CLK_01_1_6_CLK),1 (reserved),2 (1_4_CLK_11_1_2_CLK),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   EST_ACQ_OFFSET_SCALER          = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EST_TRC_OFFSET_SCALER          = "
  tree.end
  tree "RXF_SRC1_DACC_CTL"
   group.long 0x118--0x11b "RXF_SRC1_DACC_CTL (at 0x90004c18) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   MICRO_DACC_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   DACC_DC_OFFSET_POLARITY        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x18 "  [24:23]   DACC_MULT_PRESCALER            = " "0 (0_25),1 (0_5),2 (1_0),3 (2_0) "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   NOT_USED                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   MICRO_MIX_RANGE_OVERIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   MICRO_LNA_RANGE_OVERIDE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MICRO_MIX_RANGE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x12 "  [18:17]   MICRO_LNA_RANGE                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   RXF_SBI_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   DACC_GCH_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DACC_PRD_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   DACC_DFT_UPDATE_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   DACC_FG_EST_N                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   EST_ACCUM_CLR_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   EST_OFFSET_ACCUM_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   EST_ACCUM_FREQ                 = " "0 (1_8_CLK_01_1_6_CLK),1 (reserved),2 (1_4_CLK_11_1_2_CLK),3 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   EST_ACQ_OFFSET_SCALER          = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EST_TRC_OFFSET_SCALER          = "
  tree.end
 tree.end
 tree "RXF_SRCc_FG_IOFFSET"
  tree "RXF_SRC0_FG_IOFFSET"
   group.long 0x1c--0x1f "RXF_SRC0_FG_IOFFSET (at 0x90004b1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   FG_I_OFFSET                    = "
  tree.end
  tree "RXF_SRC1_FG_IOFFSET"
   group.long 0x11c--0x11f "RXF_SRC1_FG_IOFFSET (at 0x90004c1c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   FG_I_OFFSET                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_FG_QOFFSET"
  tree "RXF_SRC0_FG_QOFFSET"
   group.long 0x20--0x23 "RXF_SRC0_FG_QOFFSET (at 0x90004b20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   FG_Q_OFFSET                    = "
  tree.end
  tree "RXF_SRC1_FG_QOFFSET"
   group.long 0x120--0x123 "RXF_SRC1_FG_QOFFSET (at 0x90004c20) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   FG_Q_OFFSET                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_DC_IOFFSET_ADJ"
  tree "RXF_SRC0_DC_IOFFSET_ADJ"
   group.long 0x24--0x27 "RXF_SRC0_DC_IOFFSET_ADJ (at 0x90004b24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   IOFFSET_ADJ                    = "
  tree.end
  tree "RXF_SRC1_DC_IOFFSET_ADJ"
   group.long 0x124--0x127 "RXF_SRC1_DC_IOFFSET_ADJ (at 0x90004c24) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   IOFFSET_ADJ                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_DC_QOFFSET_ADJ"
  tree "RXF_SRC0_DC_QOFFSET_ADJ"
   group.long 0x28--0x2b "RXF_SRC0_DC_QOFFSET_ADJ (at 0x90004b28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   QOFFSET_ADJ                    = "
  tree.end
  tree "RXF_SRC1_DC_QOFFSET_ADJ"
   group.long 0x128--0x12b "RXF_SRC1_DC_QOFFSET_ADJ (at 0x90004c28) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   QOFFSET_ADJ                    = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_ACQ_TIMER"
  tree "RXF_SRC0_DACC_ACQ_TIMER"
   group.long 0x2c--0x2f "RXF_SRC0_DACC_ACQ_TIMER (at 0x90004b2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   DACC_ACQ_COUNT                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   DACC_ACQ_TIME                  = "
  tree.end
  tree "RXF_SRC1_DACC_ACQ_TIMER"
   group.long 0x12c--0x12f "RXF_SRC1_DACC_ACQ_TIMER (at 0x90004c2c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   DACC_ACQ_COUNT                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   DACC_ACQ_TIME                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_TRC_TIMER"
  tree "RXF_SRC0_DACC_TRC_TIMER"
   group.long 0x30--0x33 "RXF_SRC0_DACC_TRC_TIMER (at 0x90004b30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   DACC_TRC_TIME                  = "
  tree.end
  tree "RXF_SRC1_DACC_TRC_TIMER"
   group.long 0x130--0x133 "RXF_SRC1_DACC_TRC_TIMER (at 0x90004c30) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1b 1 "  [27: 0]   DACC_TRC_TIME                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_CLR_TIMER"
  tree "RXF_SRC0_DACC_CLR_TIMER"
   group.long 0x34--0x37 "RXF_SRC0_DACC_CLR_TIMER (at 0x90004b34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DACC_CLR_TIME                  = "
  tree.end
  tree "RXF_SRC1_DACC_CLR_TIMER"
   group.long 0x134--0x137 "RXF_SRC1_DACC_CLR_TIMER (at 0x90004c34) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DACC_CLR_TIME                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_EST_THRESH"
  tree "RXF_SRC0_DACC_EST_THRESH"
   group.long 0x38--0x3b "RXF_SRC0_DACC_EST_THRESH (at 0x90004b38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   EST_THRESHOLD                  = "
  tree.end
  tree "RXF_SRC1_DACC_EST_THRESH"
   group.long 0x138--0x13b "RXF_SRC1_DACC_EST_THRESH (at 0x90004c38) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1e 1 "  [30: 0]   EST_THRESHOLD                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_EST_IOFFSET"
  tree "RXF_SRC0_DACC_EST_IOFFSET"
   group.long 0x3c--0x3f "RXF_SRC0_DACC_EST_IOFFSET (at 0x90004b3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EST_I_DC_OFFSET                = "
  tree.end
  tree "RXF_SRC1_DACC_EST_IOFFSET"
   group.long 0x13c--0x13f "RXF_SRC1_DACC_EST_IOFFSET (at 0x90004c3c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EST_I_DC_OFFSET                = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_EST_QOFFSET"
  tree "RXF_SRC0_DACC_EST_QOFFSET"
   group.long 0x40--0x43 "RXF_SRC0_DACC_EST_QOFFSET (at 0x90004b40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EST_Q_DC_OFFSET                = "
  tree.end
  tree "RXF_SRC1_DACC_EST_QOFFSET"
   group.long 0x140--0x143 "RXF_SRC1_DACC_EST_QOFFSET (at 0x90004c40) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EST_Q_DC_OFFSET                = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_IACCUM0"
  tree "RXF_SRC0_DACC_IACCUM0"
   group.long 0x44--0x47 "RXF_SRC0_DACC_IACCUM0 (at 0x90004b44) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM0                  = "
  tree.end
  tree "RXF_SRC1_DACC_IACCUM0"
   group.long 0x144--0x147 "RXF_SRC1_DACC_IACCUM0 (at 0x90004c44) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM0                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_IACCUM1"
  tree "RXF_SRC0_DACC_IACCUM1"
   group.long 0x48--0x4b "RXF_SRC0_DACC_IACCUM1 (at 0x90004b48) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM1                  = "
  tree.end
  tree "RXF_SRC1_DACC_IACCUM1"
   group.long 0x148--0x14b "RXF_SRC1_DACC_IACCUM1 (at 0x90004c48) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM1                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_IACCUM2"
  tree "RXF_SRC0_DACC_IACCUM2"
   group.long 0x4c--0x4f "RXF_SRC0_DACC_IACCUM2 (at 0x90004b4c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM2                  = "
  tree.end
  tree "RXF_SRC1_DACC_IACCUM2"
   group.long 0x14c--0x14f "RXF_SRC1_DACC_IACCUM2 (at 0x90004c4c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM2                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_IACCUM3"
  tree "RXF_SRC0_DACC_IACCUM3"
   group.long 0x50--0x53 "RXF_SRC0_DACC_IACCUM3 (at 0x90004b50) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM3                  = "
  tree.end
  tree "RXF_SRC1_DACC_IACCUM3"
   group.long 0x150--0x153 "RXF_SRC1_DACC_IACCUM3 (at 0x90004c50) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM3                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_IACCUM4"
  tree "RXF_SRC0_DACC_IACCUM4"
   group.long 0x54--0x57 "RXF_SRC0_DACC_IACCUM4 (at 0x90004b54) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM4                  = "
  tree.end
  tree "RXF_SRC1_DACC_IACCUM4"
   group.long 0x154--0x157 "RXF_SRC1_DACC_IACCUM4 (at 0x90004c54) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_I_ACCUM4                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_QACCUM0"
  tree "RXF_SRC0_DACC_QACCUM0"
   group.long 0x58--0x5b "RXF_SRC0_DACC_QACCUM0 (at 0x90004b58) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM0                  = "
  tree.end
  tree "RXF_SRC1_DACC_QACCUM0"
   group.long 0x158--0x15b "RXF_SRC1_DACC_QACCUM0 (at 0x90004c58) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM0                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_QACCUM1"
  tree "RXF_SRC0_DACC_QACCUM1"
   group.long 0x5c--0x5f "RXF_SRC0_DACC_QACCUM1 (at 0x90004b5c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM1                  = "
  tree.end
  tree "RXF_SRC1_DACC_QACCUM1"
   group.long 0x15c--0x15f "RXF_SRC1_DACC_QACCUM1 (at 0x90004c5c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM1                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_QACCUM2"
  tree "RXF_SRC0_DACC_QACCUM2"
   group.long 0x60--0x63 "RXF_SRC0_DACC_QACCUM2 (at 0x90004b60) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM2                  = "
  tree.end
  tree "RXF_SRC1_DACC_QACCUM2"
   group.long 0x160--0x163 "RXF_SRC1_DACC_QACCUM2 (at 0x90004c60) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM2                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_QACCUM3"
  tree "RXF_SRC0_DACC_QACCUM3"
   group.long 0x64--0x67 "RXF_SRC0_DACC_QACCUM3 (at 0x90004b64) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM3                  = "
  tree.end
  tree "RXF_SRC1_DACC_QACCUM3"
   group.long 0x164--0x167 "RXF_SRC1_DACC_QACCUM3 (at 0x90004c64) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM3                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_QACCUM4"
  tree "RXF_SRC0_DACC_QACCUM4"
   group.long 0x68--0x6b "RXF_SRC0_DACC_QACCUM4 (at 0x90004b68) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM4                  = "
  tree.end
  tree "RXF_SRC1_DACC_QACCUM4"
   group.long 0x168--0x16b "RXF_SRC1_DACC_QACCUM4 (at 0x90004c68)   (shadowed - Use hwio_shadow_ptr->RXF_SRC1_DACC_QACCUM4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   DACC_Q_ACCUM4                  = "
  tree.end
 tree.end
 tree "RXF_SRCc_MICRO_DACC_UPDATE"
  tree "RXF_SRC0_MICRO_DACC_UPDATE"
   group.long 0x6c--0x6f "RXF_SRC0_MICRO_DACC_UPDATE (at 0x90004b6c)   (shadowed - Use hwio_shadow_ptr->RXF_SRC0_MICRO_DACC_UPDATE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MICRO_DACC_UPDATE              = " "0,1 "
  tree.end
  tree "RXF_SRC1_MICRO_DACC_UPDATE"
   group.long 0x16c--0x16f "RXF_SRC1_MICRO_DACC_UPDATE (at 0x90004c6c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MICRO_DACC_UPDATE              = " "0,1 "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_SSBI_INFO"
  tree "RXF_SRC0_DACC_SSBI_INFO"
   group.long 0x70--0x73 "RXF_SRC0_DACC_SSBI_INFO (at 0x90004b70) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MSB_OFFSET_SSBI_ADDR           = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   LSB_OFFSET_SSBI_ADDR           = "
  tree.end
  tree "RXF_SRC1_DACC_SSBI_INFO"
   group.long 0x170--0x173 "RXF_SRC1_DACC_SSBI_INFO (at 0x90004c70) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   MSB_OFFSET_SSBI_ADDR           = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   LSB_OFFSET_SSBI_ADDR           = "
  tree.end
 tree.end
 tree "RXF_SRCc_DACC_GAIN_MULT"
  tree "RXF_SRC0_DACC_GAIN_MULT"
   group.long 0x74--0x77 "RXF_SRC0_DACC_GAIN_MULT (at 0x90004b74) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   DACC_MULT_QVAL                 = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DACC_MULT_IVAL                 = "
  tree.end
  tree "RXF_SRC1_DACC_GAIN_MULT"
   group.long 0x174--0x177 "RXF_SRC1_DACC_GAIN_MULT (at 0x90004c74) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   DACC_MULT_QVAL                 = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DACC_MULT_IVAL                 = "
  tree.end
 tree.end
 tree "RXF_SRCc_NOTCH_CFG"
  tree "RXF_SRC0_NOTCH_CFG"
   group.long 0x78--0x7b "RXF_SRC0_NOTCH_CFG (at 0x90004b78) "
    line.long 0x0 "VALUE"
  tree.end
  tree "RXF_SRC1_NOTCH_CFG"
   group.long 0x178--0x17b "RXF_SRC1_NOTCH_CFG (at 0x90004c78) "
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "RXF_SRCc_MICRO_SYNC_CMD"
  tree "RXF_SRC0_MICRO_SYNC_CMD"
   group.long 0x7c--0x7f "RXF_SRC0_MICRO_SYNC_CMD (at 0x90004b7c) "
    line.long 0x0 "VALUE"
  tree.end
  tree "RXF_SRC1_MICRO_SYNC_CMD"
   group.long 0x17c--0x17f "RXF_SRC1_MICRO_SYNC_CMD (at 0x90004c7c) "
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "RXF_SRCc_ARM_IRQ_STATUS"
  tree "RXF_SRC0_ARM_IRQ_STATUS"
   group.long 0x80--0x83 "RXF_SRC0_ARM_IRQ_STATUS (at 0x90004b80) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   REBOOST0                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DEBOOST0                       = " "0,1 "
  tree.end
  tree "RXF_SRC1_ARM_IRQ_STATUS"
   group.long 0x90--0x93 "RXF_SRC1_ARM_IRQ_STATUS (at 0x90004b90) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   REBOOST0                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DEBOOST0                       = " "0,1 "
  tree.end
 tree.end
tree.end
tree.end

base ad:0x80010000
tree "SDCC"
  tree "MCI_POWER"
   group.long 0x0--0x3 "MCI_POWER (at 0x80010000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   OPEN_DRAIN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONTROL                        = " "0 (POWER_OFF),1 (RESERVED_ENCODING),2 (POWERUP),3 (POWERON) "
  tree.end
  tree "MCI_CLK"
   group.long 0x4--0x7 "MCI_CLK (at 0x80010004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   INVERT_IN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   INVERT_OUT                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   FLOW_ENA                       = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   WIDEBUS                        = " "0 (1_BIT_MODE),1 (4_BIT_MODE) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   PWRSAVE                        = " "0 (ALWAYS_ENABLED),1 (CLOCK_ENABLED) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   ENABLE                         = " "0 (CLOCK_DISABLED),1 (CLOCK_ENABLED) "
  tree.end
  tree "MCI_ARGUMENT"
   group.long 0x8--0xb "MCI_ARGUMENT (at 0x80010008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CMD_ARG                        = "
  tree.end
  tree "MCI_CMD"
   group.long 0xc--0xf "MCI_CMD (at 0x8001000c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   PROG_ENA                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   ENABLE                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PENDING                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   INTERRUPT                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LONGRSP                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RESPONSE                       = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CMD_INDEX                      = "
  tree.end
  tree "MCI_RESP_CMD"
   group.long 0x10--0x13 "MCI_RESP_CMD (at 0x80010010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RESPCMD                        = "
  tree.end
 tree "MCI_RESPn"
  tree "MCI_RESP0"
   group.long 0x14--0x17 "MCI_RESP0 (at 0x80010014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   STATUS                         = "
  tree.end
  tree "MCI_RESP1"
   group.long 0x18--0x1b "MCI_RESP1 (at 0x80010018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   STATUS                         = "
  tree.end
  tree "MCI_RESP2"
   group.long 0x1c--0x1f "MCI_RESP2 (at 0x8001001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   STATUS                         = "
  tree.end
  tree "MCI_RESP3"
   group.long 0x20--0x23 "MCI_RESP3 (at 0x80010020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   STATUS                         = "
  tree.end
 tree.end
  tree "MCI_DATA_TIMER"
   group.long 0x24--0x27 "MCI_DATA_TIMER (at 0x80010024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA_TIME                      = "
  tree.end
  tree "MCI_DATA_LENGTH"
   group.long 0x28--0x2b "MCI_DATA_LENGTH (at 0x80010028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATALENGTH                     = "
  tree.end
  tree "MCI_DATA_CTL"
   group.long 0x2c--0x2f "MCI_DATA_CTL (at 0x8001002c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   BLOCKSIZE                      = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   DMA_ENABLE                     = " "0 (DMA_DISABLED),1 (DMA_ENABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   MODE                           = " "0 (BLOCK_DATA_TRANSFER),1 (STREAM_DATA_TRANSFER) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   DIRECTION                      = " "0 (CONTROLLER_TO_CARD),1 (CARD_TO_CONTROLLER) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                         = " "0,1 "
  tree.end
  tree "MCI_DATA_COUNT"
   group.long 0x30--0x33 "MCI_DATA_COUNT (at 0x80010030)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATACOUNT                      = "
  tree.end
  tree "MCI_STATUS"
   group.long 0x34--0x37 "MCI_STATUS (at 0x80010034)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   DMA_DONE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   PROG_DONE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SDIO_INTR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   RXDATA_AVLBL                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   TXDATA_AVLBL                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RXFIFO_EMPTY                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   TXFIFO_EMPTY                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   RXFIFO_FULL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   TXFIFO_FULL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RXFIFO_HALF_FULL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   TXFIFO_HALF_FULL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   RXACTIVE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TXACTIVE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CMD_ACTIVE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   DATA_BLK_END                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   START_BIT_ERR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   DATAEND                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CMD_SENT                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CMD_RESPONSE_END               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RX_OVERRUN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_UNDERRUN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   DATA_TIMEOUT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_TIMEOUT                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_CRC_FAIL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_CRC_FAIL                   = " "0,1 "
  tree.end
  tree "MCI_CLEAR"
   group.long 0x38--0x3b "MCI_CLEAR (at 0x80010038)   (shadowed - Use hwio_shadow_ptr->MCI_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   DMA_DONE_CLR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   PROG_DONE_CLR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   SDIO_INTR_CLR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   DATA_BLK_END_CLR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   START_BIT_ERR_CLR              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   DATA_END_CLR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CMD_SENT_CLR                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CMD_RESP_END_CLT               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RX_OVERRUN_CLR                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_UNDERRUN_CLR                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   DATA_TIMEOUT_CLR               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CMD_TIMOUT_CLR                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_CRC_FAIL_CLR              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_CRC_FAIL_CLR               = " "0,1 "
  tree.end
 tree "MCI_INT_MASKn"
  tree "MCI_INT_MASK0"
   group.long 0x3c--0x3f "MCI_INT_MASK0 (at 0x8001003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   MASK24                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   MASK23                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MASK22                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   MASK21                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   MASK20                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MASK19                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   MASK18                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   MASK17                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   MASK16                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MASK15                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   MASK14                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   MASK13                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   MASK12                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MASK11                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MASK10                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MASK9                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MASK8                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MASK7                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MASK6                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MASK5                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MASK4                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK3                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MASK2                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MASK1                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MASK0                          = " "0,1 "
  tree.end
  tree "MCI_INT_MASK1"
   group.long 0x40--0x43 "MCI_INT_MASK1 (at 0x80010040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   MASK24                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   MASK23                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   MASK22                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x15--0x15 "  [   21]   MASK21                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   MASK20                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MASK19                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   MASK18                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   MASK17                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   MASK16                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   MASK15                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   MASK14                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   MASK13                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   MASK12                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   MASK11                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MASK10                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MASK9                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   MASK8                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   MASK7                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MASK6                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MASK5                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MASK4                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK3                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   MASK2                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MASK1                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MASK0                          = " "0,1 "
  tree.end
 tree.end
  tree "MCI_FIFO_COUNT"
   group.long 0x44--0x47 "MCI_FIFO_COUNT (at 0x80010044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   DATA_COUNT                     = "
  tree.end
  tree "MCI_FIFO"
   group.long 0x80--0x83 "MCI_FIFO (at 0x80010080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "MCI_ABORT"
   group.long 0xc0--0xc3 "MCI_ABORT (at 0x800100c0)   (shadowed - Use hwio_shadow_ptr->MCI_ABORT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCIABORT                       = " "0,1 "
  tree.end
  tree "MCI_START_ADDR"
   group.long 0xc4--0xc7 "MCI_START_ADDR (at 0x800100c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   START_ADDR                     = "
  tree.end
  tree "MCI_DMA_CONFIG"
   group.long 0xc8--0xcb "MCI_DMA_CONFIG (at 0x800100c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   RX_THRESH                      = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   TX_THRESH                      = "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   TEST_ENA                       = " "0 (DEFAULT),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   ADDR_INC_ENA                   = " "0 (reserved),1 (DEFAULT) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   HLOCK_ENA                      = " "0 (reserved),1 (DEFAULT) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ENDIAN_CHANGE                  = " "0 (DEFAULT),1 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_BEAT                       = "
  tree.end
  tree "MCI_TESTBUS_CONFIG"
   group.long 0xcc--0xcf "MCI_TESTBUS_CONFIG (at 0x800100cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TESTBUS_ENA                    = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TESTBUS_SEL                    = " "0,1,2,3 "
  tree.end
  tree "MCI_TEST_CTL"
   group.long 0xd0--0xd3 "MCI_TEST_CTL (at 0x800100d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   REGTEST                        = " "0 (NORMAL_MODE),1 (TEST_MODE) "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   FIFOTEST                       = " "0 (DEFAULT_NORMAL_MODE),1 (TEST_MODE_01),2 (RESERVED_ENCODING),3 (TEST_MODE_11) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ITEN                           = " "0 (NORMAL_MODE),1 (INTEGRATION_TEST_MODE) "
  tree.end
  tree "MCI_TEST_INPUT"
   group.long 0xd4--0xd7 "MCI_TEST_INPUT (at 0x800100d4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MCICMDIN                       = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   MCIDATIN                       = "
  tree.end
  tree "MCI_TEST_OUT"
   group.long 0xd8--0xdb "MCI_TEST_OUT (at 0x800100d8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MCICMDOUT                      = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x6--0x9 1 "  [ 9: 6]   MCIDATOUT                      = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   MCIINTR1                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCIINTR0                       = " "0,1 "
  tree.end
  tree "MCI_PERPH_ID0"
   group.long 0xe0--0xe3 "MCI_PERPH_ID0 (at 0x800100e0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   PARTNUMBER0                    = "
  tree.end
  tree "MCI_PERPH_ID1"
   group.long 0xe4--0xe7 "MCI_PERPH_ID1 (at 0x800100e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DESIGNER0                      = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PARTNUMBER1                    = "
  tree.end
  tree "MCI_PERPH_ID2"
   group.long 0xe8--0xeb "MCI_PERPH_ID2 (at 0x800100e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   REVISION                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DESIGNER1                      = "
  tree.end
  tree "MCI_PERPH_ID3"
   group.long 0xec--0xef "MCI_PERPH_ID3 (at 0x800100ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   CONFIG                         = "
  tree.end
  tree "MCI_PCELL_ID0"
   group.long 0xf0--0xf3 "MCI_PCELL_ID0 (at 0x800100f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   MCIPCELL_ID0                   = "
  tree.end
  tree "MCI_PCELL_ID1"
   group.long 0xf4--0xf7 "MCI_PCELL_ID1 (at 0x800100f4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   MCIPCELL_ID1                   = "
  tree.end
  tree "MCI_PCELL_ID2"
   group.long 0xf8--0xfb "MCI_PCELL_ID2 (at 0x800100f8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   MCIPCELL_ID2                   = "
  tree.end
  tree "MCI_PCELL_ID3"
   group.long 0xfc--0xff "MCI_PCELL_ID3 (at 0x800100fc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   MCIPCELL_ID3                   = "
  tree.end
tree.end

base ad:0x80014000
tree "SDRAM_REGS"
  tree "SDRAM_OPT_CFG"
   group.long 0x0--0x3 "SDRAM_OPT_CFG (at 0x80014000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x19--0x1f 1 "  [31:25]   RESERVED_BITS31_25             = "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   OPTIMIZER_EN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x16--0x17 "  [23:22]   P3_PRIORITY                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x14--0x15 "  [21:20]   P2_PRIORITY                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   P1_PRIORITY                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   P0_PRIORITY                    = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   TIME_OUT_P3                    = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   TIME_OUT_P2                    = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIME_OUT_P1                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIME_OUT_P0                    = "
  tree.end
  tree "SDRAM_RFRSH_CFG"
   group.long 0x10--0x13 "SDRAM_RFRSH_CFG (at 0x80014010) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   RESERVED_BITS31_30             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1d "  [   29]   AUTO_SRR_EN                    = " "0 (AUTO_SRR_DISABLED),1 (AUTO_SRR_ENABLED) "
    textline ""
    bitfld.long 0x0 0x1c "  [   28]   RFRSH_RATE_EN                  = " "0 (DISABLE_REFRESH_RATE_CONTROL),1 (reserved) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BITS27                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   MAX_RFRSH_CREDIT_CNT           = " "0 (0REFRESHES),1 (1_REFRESHES),2 (2_REFRESHES),3 (3_REFRESHES),4 (4_REFRESHES),5 (5_REFRESHES),6 (6_REFRESHES),7 (7_REFRESHES) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BITS23                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   MAX_PEND_RFRSH_CNT             = " "0 (6_REFRESHES),1 (4_REFRESHES),2 (3_REFRESHES),3 (2_REFRESHES),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (7_REFRESHES) "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BITS19                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   RFRSH_RATE                     = " "0 (1X),1 (4X),2 (3X),3 (2X),4 (1XZ),5 (1_2X),6 (1_3X),7 (1_4X) "
    textline ""
    hexmask.long.word 0x0 0x4--0xf 1 "  [15: 4]   RFRSH_TMR                      = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   RFRSH_EN                       = " "0 (DISABLE_AUTO_REFRESH),1 (ENABLE_AUTO_REFRESH) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   DEEP_PWR_DOWN_EN               = " "0 (DISABLE_DPD),1 (ENABLE_DPD) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CS1_SELF_RFRSH                 = " "0 (ACTIVE),1 (SELF_REFRESH) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CS0_SELF_RFRSH                 = " "0 (ACTIVE),1 (SELF_REFRESH) "
  tree.end
  tree "SDRAM_DEV_PARAM_CFG1"
   group.long 0x14--0x17 "SDRAM_DEV_PARAM_CFG1 (at 0x80014014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   RESERVED_BITS31_30             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   CAS_LAT                        = " "0 (2_CLOCKS),1 (3_CLOCKS),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BITS27                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   ROW_SIZE                       = " "0 (12_BITS),1 (13_BITS),2 (14_BITS),3 (15_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (1_4X) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BITS23                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x14--0x16 "  [22:20]   COL_SIZE                       = " "0 (7_BITS),1 (8_BITS),2 (9_BITS),3 (10_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (1_4X) "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   TRFC                           = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   TRP                            = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BITS11                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   TRAS                           = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TRC                            = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   BANK_SIZE                      = " "0 (2_BITS),1 (RESERVED_PROGRAMMING) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   PWR_DOWN_PER_CS_EN             = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   BANK_IL                        = " "0 (LINEAR_MEMORY_MAP),1 (INTERLEAVING) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CLK_PWR_DOWN_EN                = " "0 (DISABLE_CLOCK_SHUTDOWN),1 (ENABLE_CLOCK_SHUTDOWN) "
  tree.end
  tree "SDRAM_DEV_PARAM_CFG2"
   group.long 0x18--0x1b "SDRAM_DEV_PARAM_CFG2 (at 0x80014018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BITS31                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1e "  [30:28]   TMRD                           = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   RESERVED_BITS27                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x1a "  [26:24]   TXP                            = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x16--0x17 "  [23:22]   RESERVED_BITS23_22             = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   TXSR                           = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   TWR                            = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BITS11                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   TRCD                           = " "0 (0X1_RESERVED),1 (reserved),2 (3_CLOCKS),3 (4_CLOCKS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (1_4X) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BITS7                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   TDAL                           = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BITS3                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRRD                           = " "0 (reserved),1 (2_CLOCKS),2 (3_CLOCKS),3 (0X7_RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (1_4X) "
  tree.end
  tree "SDRAM_DEV_PARAM_CFG3"
   group.long 0x1c--0x1f "SDRAM_DEV_PARAM_CFG3 (at 0x8001401c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS31_16             = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   TCKE                           = " "0 (NO_GAP_REQUIRED),1 (1_CYCLE_GAP),2 (2_CYCLE_GAP),3 (3_CYCLE_GAP),4 (reserved),5 (reserved),6 (reserved),7 (7_CYCLE_GAP) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BITS11                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   TWR2RD                         = " "0 (NO_GAP_REQUIRED),1 (1_CYCLE_GAP),2 (2_CYCLE_GAP),3 (3_CYCLE_GAP),4 (reserved),5 (reserved),6 (reserved),7 (7_CYCLE_GAP) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BITS7                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   TIOTRUN_VAL                    = " "0 (reserved),1 (1_CYCLE_GAP),2 (2_CYCLE_GAP),3 (3_CYCLE_GAP),4 (reserved),5 (reserved),6 (reserved),7 (7_CYCLE_GAP) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RESERVED_BITS3_2               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BURST_LEN                      = " "0 (4_WORD_BURST_PER_ACCESS),1 (8_WORD_BURST_PER_ACCESS),2 (0X3_RESERVED),3 (reserved) "
  tree.end
  tree "SDRAM_CTRL_CFG"
   group.long 0x20--0x23 "SDRAM_CTRL_CFG (at 0x80014020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   BANKN_PAGE_OPEN_EN             = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   BYPASS_CMDSM_RDY               = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   CLOSE_PAGE_DIS                 = " "0 (ENABLE),1 (DISABLE) "
    textline ""
    bitfld.long 0x0 0x15 "  [   21]   EARLY_PWR_DOWN_EXIT_EN         = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x14 "  [   20]   USE_KEEP_PAGE_OPEN             = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x13 "  [   19]   DTCT_CONCURRENT_PRECHRG_EN     = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   PG_MISS_APRCHRG_EN             = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x11 "  [   17]   RD_FIFO_OP_DISABLE             = " "0 (ENABLE_FIFO_OPERATION),1 (DISABLE_FIFO_OPERATION) "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   USE_FB_CLK_FOR_PAD_IE          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   FIFO_CLK_SYNC                  = " "0 (ASYNCHRONOUS),1 (SYNCHRONOUS) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   CLK_PHASE_ALIGN                = " "0 (EXTERNAL_CLOCK_IS_OFF_OF_CC_EBI1_2X_CLK_NO_PHASE_RELATION_WITH_MEM_CLK),1 (EXTERNAL_CLOCK_HAS_SAME_PHASE_AS_MEM_CLK) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   DQ_DQS_PAD_OE                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   FORCE_DDR_CLK_OFF              = " "0 (NO_FORCED_CLOCK_SHUTDOWN),1 (FORCE_CLOCK_SHUTDOWN) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   CLK_OFF_TMR_VAL                = " "0 (CTRL_IS_IDLE_FOR_32_CLOCK_CYCLES),1 (CTRL_IS_IDLE_FOR_4_CLOCK_CYCLES),2 (CTRL_IS_IDLE_FOR_8_CLOCK_CYCLES),3 (CTRL_IS_IDLE_FOR_12_CLOCK_CYCLES),4 (CTRL_IS_IDLE_FOR_16_CLOCK_CYCLES),5 (CTRL_IS_IDLE_FOR_24_CLOCK_CYCLES),6 (CTRL_IS_IDLE_FOR_48_CLOCK_CYCLES),7 (CTRL_IS_IDLE_FOR_63_CLOCK_CYCLES) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   READ_FIFO_OUT_REG              = " "0 (DO_NOT_REGISTER),1 (REGISTER) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   READ_FIFO_START_EARLY          = " "0 (DO_NOT_START_EARLY),1 (START_1_CLOCK_EARLY) "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RESERVED_BITS6_5               = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   BUS_MEM_CLK_SYNC               = " "0 (ASYNCHRONOUS),1 (SYNCHRONOUS) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   CMD_BPRSR_EN                   = " "0 (BPRSR_DISABLED),1 (BPRSR_ENABLED) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   B2BCMD_ACK_EN                  = " "0 (BACK2BACK_COMMAND_PIPELINE_DISABLED),1 (BACK2BACK_COMMAND_PIPELINE_ENABLED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CMD_OPT_EN                     = " "0 (PIPELINE_DISABLED),1 (PIPELINE_ENABLED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   DATA_BUS_WIDTH                 = " "0 (16_BIT),1 (32_BIT) "
  tree.end
  tree "SDRAM_DEV_INIT_CFG"
   group.long 0x24--0x27 "SDRAM_DEV_INIT_CFG (at 0x80014024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   DEEP_PWR_DOWN_DONE             = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   ADDR_BUS                       = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   BANK_ADDR                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   STATUS_REG_READ_DONE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SELF_REFRESH_EXIT_DONE         = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   SELF_REFRESH_START_DONE        = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   REFRESH_DONE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   PRECHARGE_DONE                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CONFIG_DONE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ACTIVE_CHIP_SELECTS            = " "0 (reserved),1 (CHIP_SELECT0),2 (CHIP_SELECT1),3 (BOTH_CHIP_SELECTS) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   STATUS_REG_READ                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SELF_REFRESH_EXIT              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SELF_REFRESH_START             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   REFRESH_START                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PRECHARGE_START                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CONFIG_START                   = " "0,1 "
  tree.end
  tree "SDRAM_COL_ROW_SIZE_CFG"
   group.long 0x28--0x2b "SDRAM_COL_ROW_SIZE_CFG (at 0x80014028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x15--0x1f 1 "  [31:21]   RESERVED_31_21                 = "
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   INDEPENDENT_SIZE_CS_ENA        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x13 "  [19:18]   CS1_REFRESH_RATIO              = " "0 (RATION_1_1_TO_THE_SYSTEM_REFRESH_RATE),1 (RATION_1_2_TO_THE_SYSTEM_REFRESH_RATE),2 (RATION_1_4_TO_THE_SYSTEM_REFRESH_RATE),3 (RATION_1_8_TO_THE_SYSTEM_REFRESH_RATE) "
    textline ""
    bitfld.long 0x0 0x10--0x11 "  [17:16]   CS0_REFRESH_RATIO              = " "0 (RATION_1_1_TO_THE_SYSTEM_REFRESH_RATE),1 (RATION_1_2_TO_THE_SYSTEM_REFRESH_RATE),2 (RATION_1_4_TO_THE_SYSTEM_REFRESH_RATE),3 (RATION_1_8_TO_THE_SYSTEM_REFRESH_RATE) "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   CS1_ROW_SIZE                   = " "0 (12_BITS),1 (13_BITS),2 (14_BITS),3 (15_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (CTRL_IS_IDLE_FOR_63_CLOCK_CYCLES) "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   RESERVED_BIT11                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   CS1_COL_SIZE                   = " "0 (7_BITS),1 (8_BITS),2 (9_BITS),3 (10_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (CTRL_IS_IDLE_FOR_63_CLOCK_CYCLES) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CS0_ROW_SIZE                   = " "0 (12_BITS),1 (13_BITS),2 (14_BITS),3 (15_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (CTRL_IS_IDLE_FOR_63_CLOCK_CYCLES) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CS0_COL_SIZE                   = " "0 (7_BITS),1 (8_BITS),2 (9_BITS),3 (10_BITS),4 (0X7_RESERVED),5 (reserved),6 (reserved),7 (CTRL_IS_IDLE_FOR_63_CLOCK_CYCLES) "
  tree.end
  tree "SDRAM_HW_DEV_INIT_CFG"
   group.long 0x2c--0x2f "SDRAM_HW_DEV_INIT_CFG (at 0x8001402c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x17--0x1f 1 "  [31:23]   RESERVED_31_23                 = "
    textline ""
    hexmask.long.word 0x0 0x8--0x16 1 "  [22: 8]   EMRS_VAL                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_7_5                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   START_INIT_SEQ_DONE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_3_1                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   START_INIT_SEQ                 = " "0,1 "
  tree.end
  tree "SDRAM_CDCM_CFG"
   group.long 0x30--0x33 "SDRAM_CDCM_CFG (at 0x80014030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xc--0x1f 1 "  [31:12]   RESERVED_31_12                 = "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CDC_DEBUG_MUX_SEL              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   CDC_CHAR_DQS_IE_EN             = " "0 (DQ_DQS_IE_DISABLED),1 (DQ_DQS_IE_ENABLED) "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   AUTOCALIB_CDC                  = " "0 (DISABLED),1 (ENABLED_EVERY_512),2 (ENABLED_EVERY_16K),3 (ENABLED_EVERY_64K),4 (ENABLED_EVERY_256K),5 (ENABLED_EVERY_512_K),6 (ENABLED_EVERY_1024_K),7 (ENABLED_EVERY_32) "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CDC_TEST_MUX_SEL               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   CDC_MASTER_TEST_SEL            = " "0 (SELECTS_SLAVE_TEST_SIGNALS),1 (SELECTS_MASTER_TEST_SIGNALS) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   CDCM_START_CAL                 = " "0 (STOP_CALIBRATION),1 (START_CALIBRATION) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   CDCM_LOAD_MASTER               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CDCM_PWR_DOWN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CDCM_BYPASS_N                  = " "0 (CDCM_DISABLE),1 (CDCM_ENABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CDCM_CLMP                      = " "0 (ACTIVE_MODE),1 (CLAMP_CDC_SIGNALS) "
  tree.end
  tree "SDRAM_CDCM_INTERNAL1"
   group.long 0x34--0x37 "SDRAM_CDCM_INTERNAL1 (at 0x80014034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_31_24                 = "
    textline ""
    bitfld.long 0x0 0x17 "  [   23]   HALF_STEP_MODE                 = " "0 (HALF_STEP_MODE_DISABLED),1 (HALF_STEP_MODE_ENABLED) "
    textline ""
    bitfld.long 0x0 0x16 "  [   22]   JITTER_LOCK                    = " "0 (LOCK_DETECTOR_SET_IN_JUST_MODE),1 (LOCK_DETECTOR_SET_IN_JITTER_MODE) "
    textline ""
    hexmask.long.byte 0x0 0xf--0x15 1 "  [21:15]   START_VAL                      = "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   JUST_PULSES_LOCK_DETECT        = " "0 (3_JUST_PULSE),1 (4_JUST_PULSES),2 (5_JUST_PULSES),3 (8_JUST_PULSES) "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   SDR_MODE                       = " "0 (SDR_MODE_DISABLED),1 (SDR_MODE_ENABLED) "
    textline ""
    bitfld.long 0x0 0xa--0xb "  [11:10]   PHASE_OUTPUT_SEL               = " "0 (OUTPUT_OF_1ST_DELAY_UNIT),1 (OUTPUT_FROM_2ND_DELAY_UNIT),2 (OUTPUT_FROM_3RD_DELAY_UNIT),3 (OUTPUT_FROM_4TH_DELAY_UNIT) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PHASE_WINDOW                   = " "0 (5_DELAY_UNITS),1 (6_DELAY_UNITS),2 (7_DELAY_UNITS),3 (8_DELAY_UNITS) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   PROBE_PAD_EN                   = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   CLOCK_DIV_CTRL                 = " "0 (DIVIDE_BY_4),1 (DIVIDE_BY_8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   WRAP_EN                        = " "0 (NO_WRAP_ALLOWED),1 (WRAP_MODE_IS_ENABLED) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   OUTPUT_TEST_EN                 = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESERVED_3_0                   = "
  tree.end
 tree "SDRAM_CDCn_CFG"
  tree "SDRAM_CDC0_CFG"
   group.long 0x38--0x3b "SDRAM_CDC0_CFG (at 0x80014038) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS_31_16            = "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   AUTOLOAD_SLAVE_CDCN            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   CDCN_BYPASS_N                  = " "0 (CDC_SLAVE_DISABLE),1 (CDC_SLAVE_ENABLE) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   CDCN_CLMP                      = " "0 (ACTIVE_MODE),1 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x9--0xc 1 "  [12: 9]   CDCN_INT2_BITS3_0              = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CDCN_LOAD_SLAVE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   CDCN_LOAD_OFFSET               = " "0 (ADD_OFFSET_VALUE),1 (LOAD_OFFSET_VALUE) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CDCN_OFFSET_VAL                = "
  tree.end
  tree "SDRAM_CDC1_CFG"
   group.long 0x3c--0x3f "SDRAM_CDC1_CFG (at 0x8001403c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS_31_16            = "
    textline ""
    bitfld.long 0x0 0xf "  [   15]   AUTOLOAD_SLAVE_CDCN            = " "0 (DISABLED),1 (ENABLED) "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   CDCN_BYPASS_N                  = " "0 (CDC_SLAVE_DISABLE),1 (CDC_SLAVE_ENABLE) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   CDCN_CLMP                      = " "0 (ACTIVE_MODE),1 (reserved) "
    textline ""
    hexmask.long.byte 0x0 0x9--0xc 1 "  [12: 9]   CDCN_INT2_BITS3_0              = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   CDCN_LOAD_SLAVE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   CDCN_LOAD_OFFSET               = " "0 (ADD_OFFSET_VALUE),1 (LOAD_OFFSET_VALUE) "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CDCN_OFFSET_VAL                = "
  tree.end
 tree.end
  tree "SDRAM_CDCM_STATUS"
   group.long 0x44--0x47 "SDRAM_CDCM_STATUS (at 0x80014044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   DEV_SRR_VALUE                  = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BITS_15_9             = "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   CDCM_CALIB_ERR                 = " "0 (NO_ERROR),1 (CDCN_UNABLE_TO_LOCK) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   CDCM_CALIB_DONE                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CDCM_CAL_VAL                   = "
  tree.end
  tree "SDRAM_CLOCK_VOLTAGE_SWITCH_CFG"
   group.long 0x48--0x4b "SDRAM_CLOCK_VOLTAGE_SWITCH_CFG (at 0x80014048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1e--0x1f "  [31:30]   RESERVED_BITS31_30             = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1c--0x1d "  [29:28]   CLK_VOLT_SWITCH_STATUS         = " "0 (reserved),1 (CDCM_LOAD_CALB_DONE),2 (CDC_CALB_DONE),3 (CDC_SLAVE_LOAD_DONE) "
    textline ""
    bitfld.long 0x0 0x19--0x1b "  [27:25]   RESERVED_BITS27_25             = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   STALL_CTRL_STATUS              = " "0 (CTRL_NOT_IN_STALL_MODE),1 (CTRL_IN_STALL_MODE) "
    textline ""
    bitfld.long 0x0 0x17--0x17 "  [   23]   RESERVED_BITS23                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x16 1 "  [22:16]   CDCM_START_VAL                 = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   UPDATE_SLAVE_DEL_VAL           = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   CDC_DEL_OFFSET_VAL             = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RESERVED_BITS6                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CLK_VOLT_SWITCH_EN             = " "0 (NO_SWITCH),1 (LD_CDCM_CALB),2 (CALB_REQD),3 (LD_CDC_SLAVE) "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RESERVED_BITS3_1               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   STALL_CTRL                     = " "0 (CTRL_IS_IN_FUNCTIONAL_MODE),1 (CTRL_IS_IN_STALL_MODE) "
  tree.end
  tree "SDRAM_CLK_PWR_DOWN_CFG"
   group.long 0x4c--0x4f "SDRAM_CLK_PWR_DOWN_CFG (at 0x8001404c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x6--0xf 1 "  [15: 6]   RESERVED_BITS15_6              = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   FORCE_AR_CS_OFF                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BITS3                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_OFF_ENA                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CKE_OFF_ENA                    = " "0,1,2,3 "
  tree.end
  tree "SDRAM_PERF_MON_CFG"
   group.long 0x50--0x53 "SDRAM_PERF_MON_CFG (at 0x80014050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RESERVED_BITS15_8              = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   BPM_HW_CNTR2_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   BPM_HW_CNTR1_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BPM_HW_CNTR0_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   PERF_MON_STOP                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PERF_MON_START                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   PERF_HW_TRIG_ENA               = " "0 (SW_ENABLED_PERF_CNTRS),1 (HW_ENABLED_PERF_CNTRS) "
  tree.end
 tree "SDRAM_PERF_CNTRn_CFG"
  tree "SDRAM_PERF_CNTR0_CFG"
   group.long 0x54--0x57 "SDRAM_PERF_CNTR0_CFG (at 0x80014054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   RW_SELECT                      = " "0 (reserved),1 (READS_ONLY),2 (WRITES_ONLY),3 (BOTH_READS_AND_WRITES) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   PERF_CNTR_START_OFFSET         = " "0 (0X1_HALF_OF_THE_MAXIMUM_COUNT),1 (reserved),2 (ONE_FOURTH_OF_THE_MAXIMUM_COUNT),3 (THREE_FOURTH_OF_THE_MAXIMUM_COUNT) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   PERF_MINUS_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PERF_PARAM_SELECT              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BANK_SELECT                    = " "0 (BANK0),1 (BANK1),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (BANK7) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ALL_BANK_SELECT                = " "0 (SINGLE_BANK),1 (ALL_BANKS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0 (reserved),1 (CHIP_SELECT0),2 (CHIP_SELECT1),3 (BOTH_CHIP_SELECTS) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SAT_LOCK_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "SDRAM_PERF_CNTR1_CFG"
   group.long 0x58--0x5b "SDRAM_PERF_CNTR1_CFG (at 0x80014058)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   RW_SELECT                      = " "0 (reserved),1 (READS_ONLY),2 (WRITES_ONLY),3 (BOTH_READS_AND_WRITES) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   PERF_CNTR_START_OFFSET         = " "0 (0X1_HALF_OF_THE_MAXIMUM_COUNT),1 (reserved),2 (ONE_FOURTH_OF_THE_MAXIMUM_COUNT),3 (THREE_FOURTH_OF_THE_MAXIMUM_COUNT) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   PERF_MINUS_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PERF_PARAM_SELECT              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BANK_SELECT                    = " "0 (BANK0),1 (BANK1),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (BANK7) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ALL_BANK_SELECT                = " "0 (SINGLE_BANK),1 (ALL_BANKS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0 (reserved),1 (CHIP_SELECT0),2 (CHIP_SELECT1),3 (BOTH_CHIP_SELECTS) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SAT_LOCK_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "SDRAM_PERF_CNTR2_CFG"
   group.long 0x5c--0x5f "SDRAM_PERF_CNTR2_CFG (at 0x8001405c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xe "  [14:13]   RW_SELECT                      = " "0 (reserved),1 (READS_ONLY),2 (WRITES_ONLY),3 (BOTH_READS_AND_WRITES) "
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   PERF_CNTR_START_OFFSET         = " "0 (0X1_HALF_OF_THE_MAXIMUM_COUNT),1 (reserved),2 (ONE_FOURTH_OF_THE_MAXIMUM_COUNT),3 (THREE_FOURTH_OF_THE_MAXIMUM_COUNT) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   PERF_MINUS_EN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   PERF_PARAM_SELECT              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BANK_SELECT                    = " "0 (BANK0),1 (BANK1),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (BANK7) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   ALL_BANK_SELECT                = " "0 (SINGLE_BANK),1 (ALL_BANKS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS_SELECT                      = " "0 (reserved),1 (CHIP_SELECT0),2 (CHIP_SELECT1),3 (BOTH_CHIP_SELECTS) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SAT_LOCK_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
 tree.end
 tree "SDRAM_PERF_CNTRn_OUT"
  tree "SDRAM_PERF_CNTR0_OUT"
   group.long 0x60--0x63 "SDRAM_PERF_CNTR0_OUT (at 0x80014060)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   CNTR_VAL                       = "
  tree.end
  tree "SDRAM_PERF_CNTR1_OUT"
   group.long 0x64--0x67 "SDRAM_PERF_CNTR1_OUT (at 0x80014064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   CNTR_VAL                       = "
  tree.end
  tree "SDRAM_PERF_CNTR2_OUT"
   group.long 0x68--0x6b "SDRAM_PERF_CNTR2_OUT (at 0x80014068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   CNTR_VAL                       = "
  tree.end
 tree.end
  tree "SDRAM_PERF_CNTR_STATUS"
   group.long 0x6c--0x6f "SDRAM_PERF_CNTR_STATUS (at 0x8001406c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xf 1 "  [15: 3]   RESERVED_BITS_15_3             = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   CNTR2_SATURATED                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CNTR1_SATURATED                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CNTR0_SATURATED                = " "0,1 "
  tree.end
  tree "SDRAM_TEST_BUS_CFG"
   group.long 0x70--0x73 "SDRAM_TEST_BUS_CFG (at 0x80014070) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RESERVED_BITS_31               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1e "  [30:29]   LOOP_BACK_MODE                 = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   RESERVED_BITS_28               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1b "  [27:26]   EBI1_TEST_BUS_MISR_SEL         = " "0 (reserved),1 (reserved),2 (MISR_LSBS_SELECTED),3 (MISR_MSBS_SELECTED) "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   RESERVED_BITS25                = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x14--0x18 1 "  [24:20]   SDRC_DBG_BUS_SEL               = "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   RESERVED_BITS19                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12 "  [   18]   SDRC_DBG1_SWAP                 = " "0 (NO_SWAP),1 (SWAP) "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SDRC_DBG1_D31_D16_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SDRC_DBG1_D15_D0_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BITS15                = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe "  [   14]   SDRC_DBG0_SWAP                 = " "0 (NO_SWAP),1 (SWAP) "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SDRC_DBG0_D31_D16_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   SDRC_DBG0_D15_D0_EN            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   SOPT_DBG_BUS_SEL               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BITS7                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SOPT_DBG1_SWAP                 = " "0 (NO_SWAP),1 (SWAP) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   SOPT_DBG1_D31_D16_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SOPT_DBG1_D15_D0_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BITS3                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   SOPT_DBG0_SWAP                 = " "0 (NO_SWAP),1 (SWAP) "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SOPT_DBG0_D31_D16_EN           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SOPT_DBG0_D15_D0_EN            = " "0,1 "
  tree.end
  tree "SDRAM_MISR_CTRL"
   group.long 0x74--0x77 "SDRAM_MISR_CTRL (at 0x80014074) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x4--0xf 1 "  [15: 4]   RESERVED_BITS15_4              = "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   EBI1_MISR_CTRL                 = " "0 (ADDRESS),1 (READ_DATA),2 (WRITE_DATA),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   EBI1_MISR_EN                   = " "0 (DISABLE),1 (ENABLE) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   EBI1_MISR_RESET                = " "0 (OUT_OF_RESET),1 (RESET) "
  tree.end
  tree "SDRAM_MISR_OUT0"
   group.long 0x78--0x7b "SDRAM_MISR_OUT0 (at 0x80014078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EBI1_MISR_OUT0                 = "
  tree.end
  tree "SDRAM_MISR_OUT1"
   group.long 0x7c--0x7f "SDRAM_MISR_OUT1 (at 0x8001407c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EBI1_MISR_OUT1                 = "
  tree.end
  tree "SDRAM_FPGA_CONTROLLER_CFG1"
   group.long 0x80--0x83 "SDRAM_FPGA_CONTROLLER_CFG1 (at 0x80014080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x7--0xf 1 "  [15: 7]   DQS_SHIFT_VAL0                 = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RESERVED_BITS6_0               = "
  tree.end
  tree "SDRAM_FPGA_CONTROLLER_CFG2"
   group.long 0x84--0x87 "SDRAM_FPGA_CONTROLLER_CFG2 (at 0x80014084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   DQS_SEL_VAL                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RESERVED_BIT7_6                = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DQS_CLK_SEL_VAL                = "
  tree.end
  tree "SDRAM_FPGA_CONTROLLER_CFG3"
   group.long 0x88--0x8b "SDRAM_FPGA_CONTROLLER_CFG3 (at 0x80014088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DQS_SHIFT_VAL1                 = "
  tree.end
  tree "SDRAM_FPGA_CONTROLLER_CFG4"
   group.long 0x8c--0x8f "SDRAM_FPGA_CONTROLLER_CFG4 (at 0x8001408c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DQS_CLK_SHIFT_VAL0             = "
  tree.end
  tree "SDRAM_FPGA_CONTROLLER_CFG5"
   group.long 0x90--0x93 "SDRAM_FPGA_CONTROLLER_CFG5 (at 0x80014090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DQS_CLK_SHIFT_VAL1             = "
  tree.end
tree.end

base ad:0x90004200
tree "SLEEP_CTL"
 tree "SLEEPn_RTC_ARM"
  tree "SLEEP0_RTC_ARM"
   group.long 0x0--0x3 "SLEEP0_RTC_ARM (at 0x90004200)   (shadowed - Use hwio_shadow_ptr->SLEEP0_RTC_ARM to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARMED                          = " "0,1 "
  tree.end
  tree "SLEEP1_RTC_ARM"
   group.long 0x68--0x6b "SLEEP1_RTC_ARM (at 0x90004268) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARMED                          = " "0,1 "
  tree.end
  tree "SLEEP2_RTC_ARM"
   group.long 0xd0--0xd3 "SLEEP2_RTC_ARM (at 0x900042d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARMED                          = " "0,1 "
  tree.end
 tree.end
 tree "SLEEPn_MICRO_START"
  tree "SLEEP0_MICRO_START"
   group.long 0x4--0x7 "SLEEP0_MICRO_START (at 0x90004204) "
    line.long 0x0 "VALUE"
  tree.end
  tree "SLEEP1_MICRO_START"
   group.long 0x6c--0x6f "SLEEP1_MICRO_START (at 0x9000426c) "
    line.long 0x0 "VALUE"
  tree.end
  tree "SLEEP2_MICRO_START"
   group.long 0xd4--0xd7 "SLEEP2_MICRO_START (at 0x900042d4) "
    line.long 0x0 "VALUE"
  tree.end
 tree.end
 tree "SLEEPn_FINE_TIME"
  tree "SLEEP0_FINE_TIME"
   group.long 0x8--0xb "SLEEP0_FINE_TIME (at 0x90004208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP1_FINE_TIME"
   group.long 0x70--0x73 "SLEEP1_FINE_TIME (at 0x90004270) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP2_FINE_TIME"
   group.long 0xd8--0xdb "SLEEP2_FINE_TIME (at 0x900042d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
 tree.end
 tree "SLEEPn_COARSE_TIME"
  tree "SLEEP0_COARSE_TIME"
   group.long 0xc--0xf "SLEEP0_COARSE_TIME (at 0x9000420c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP1_COARSE_TIME"
   group.long 0x74--0x77 "SLEEP1_COARSE_TIME (at 0x90004274)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP2_COARSE_TIME"
   group.long 0xdc--0xdf "SLEEP2_COARSE_TIME (at 0x900042dc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree.end
 tree "SLEEPn_COARSE_TIME_LATCH"
  tree "SLEEP0_COARSE_TIME_LATCH"
   group.long 0x10--0x13 "SLEEP0_COARSE_TIME_LATCH (at 0x90004210)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
  tree "SLEEP1_COARSE_TIME_LATCH"
   group.long 0x78--0x7b "SLEEP1_COARSE_TIME_LATCH (at 0x90004278)   (shadowed - Use hwio_shadow_ptr->SLEEP1_COARSE_TIME_LATCH to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
  tree "SLEEP2_COARSE_TIME_LATCH"
   group.long 0xe0--0xe3 "SLEEP2_COARSE_TIME_LATCH (at 0x900042e0)   (shadowed - Use hwio_shadow_ptr->SLEEP2_COARSE_TIME_LATCH to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
 tree.end
 tree "SLEEPn_WAKEUP_TIME"
  tree "SLEEP0_WAKEUP_TIME"
   group.long 0x14--0x17 "SLEEP0_WAKEUP_TIME (at 0x90004214)   (shadowed - Use hwio_shadow_ptr->SLEEP0_WAKEUP_TIME to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP1_WAKEUP_TIME"
   group.long 0x7c--0x7f "SLEEP1_WAKEUP_TIME (at 0x9000427c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP2_WAKEUP_TIME"
   group.long 0xe4--0xe7 "SLEEP2_WAKEUP_TIME (at 0x900042e4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree.end
 tree "SLEEPn_WAKEUP_TIME_LATCH"
  tree "SLEEP0_WAKEUP_TIME_LATCH"
   group.long 0x18--0x1b "SLEEP0_WAKEUP_TIME_LATCH (at 0x90004218)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
  tree "SLEEP1_WAKEUP_TIME_LATCH"
   group.long 0x80--0x83 "SLEEP1_WAKEUP_TIME_LATCH (at 0x90004280)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
  tree "SLEEP2_WAKEUP_TIME_LATCH"
   group.long 0xe8--0xeb "SLEEP2_WAKEUP_TIME_LATCH (at 0x900042e8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LATCHING                       = " "0,1 "
  tree.end
 tree.end
 tree "SLEEPn_FINE_COUNT_VAL"
  tree "SLEEP0_FINE_COUNT_VAL"
   group.long 0x1c--0x1f "SLEEP0_FINE_COUNT_VAL (at 0x9000421c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP1_FINE_COUNT_VAL"
   group.long 0x84--0x87 "SLEEP1_FINE_COUNT_VAL (at 0x90004284)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "SLEEP2_FINE_COUNT_VAL"
   group.long 0xec--0xef "SLEEP2_FINE_COUNT_VAL (at 0x900042ec)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
 tree.end
 tree "SLEEPn_COARSE_COUNT_VAL"
  tree "SLEEP0_COARSE_COUNT_VAL"
   group.long 0x20--0x23 "SLEEP0_COARSE_COUNT_VAL (at 0x90004220)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP1_COARSE_COUNT_VAL"
   group.long 0x88--0x8b "SLEEP1_COARSE_COUNT_VAL (at 0x90004288)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "SLEEP2_COARSE_COUNT_VAL"
   group.long 0xf0--0xf3 "SLEEP2_COARSE_COUNT_VAL (at 0x900042f0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
 tree.end
 tree "SLEEPn_STATUS"
  tree "SLEEP0_STATUS"
   group.long 0x24--0x27 "SLEEP0_STATUS (at 0x90004224)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WARMUP                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ONLINE                         = " "0,1 "
  tree.end
  tree "SLEEP1_STATUS"
   group.long 0x8c--0x8f "SLEEP1_STATUS (at 0x9000428c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WARMUP                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ONLINE                         = " "0,1 "
  tree.end
  tree "SLEEP2_STATUS"
   group.long 0xf4--0xf7 "SLEEP2_STATUS (at 0x900042f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   WARMUP                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLEEP                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ONLINE                         = " "0,1 "
  tree.end
 tree.end
 tree "SLEEPn_MODEM_STATUS_ENABLE"
  tree "SLEEP0_MODEM_STATUS_ENABLE"
   group.long 0x2c--0x2f "SLEEP0_MODEM_STATUS_ENABLE (at 0x9000422c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLED                        = " "0,1 "
  tree.end
  tree "SLEEP1_MODEM_STATUS_ENABLE"
   group.long 0x94--0x97 "SLEEP1_MODEM_STATUS_ENABLE (at 0x90004294) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLED                        = " "0,1 "
  tree.end
  tree "SLEEP2_MODEM_STATUS_ENABLE"
   group.long 0xfc--0xff "SLEEP2_MODEM_STATUS_ENABLE (at 0x900042fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLED                        = " "0,1 "
  tree.end
 tree.end
 tree "SLEEPn_INT_EN"
  tree "SLEEP0_INT_EN"
   group.long 0x30--0x33 "SLEEP0_INT_EN (at 0x90004230) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_INT                      = " "0,1 "
  tree.end
  tree "SLEEP1_INT_EN"
   group.long 0x98--0x9b "SLEEP1_INT_EN (at 0x90004298) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_INT                      = " "0,1 "
  tree.end
  tree "SLEEP2_INT_EN"
   group.long 0x100--0x103 "SLEEP2_INT_EN (at 0x90004300) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_INT                      = " "0,1 "
  tree.end
 tree.end
  tree "FEE_SLEEP_XTAL_COUNT"
   group.long 0xbc--0xbf "FEE_SLEEP_XTAL_COUNT (at 0x900042bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   LATCHING                       = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
  tree "FEE_SLEEP_XTAL_FREQ_ERR"
   group.long 0xc0--0xc3 "FEE_SLEEP_XTAL_FREQ_ERR (at 0x900042c0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1a 1 "  [26: 0]   DATA                           = "
  tree.end
tree.end

base ad:0x80018000
tree "SSBI"
  tree "SSBI_WRAPPER_SSBI_CTL"
   group.long 0x0--0x3 "SSBI_WRAPPER_SSBI_CTL (at 0x80018000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   WAKEUP_FINAL_CNT               = "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   SSBI_DATA_PDEN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   ACTIVATE_RESERVE               = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   DISABLE_TERM_SYM               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   SLAVE_ID                       = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   FTM_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   SEL_RD_DATA                    = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_SSBI_INT                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SSBI_DATA_DEL                  = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IDLE_SYMS                      = " "0,1,2,3 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_RESET"
   group.long 0x4--0x7 "SSBI_WRAPPER_SSBI_RESET (at 0x80018004)   (shadowed - Use hwio_shadow_ptr->SSBI_WRAPPER_SSBI_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_CMD"
   group.long 0x8--0xb "SSBI_WRAPPER_SSBI_CMD (at 0x80018008)   (shadowed - Use hwio_shadow_ptr->SSBI_WRAPPER_SSBI_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1b--0x1b "  [   27]   SEND_TERM_SYM                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1a--0x1a "  [   26]   WAKEUP_SLAVE                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   USE_ENABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   RDWRN                          = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REG_ADD                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
  tree "SSBI_WRAPPER_SSBI_BYPASS"
   group.long 0xc--0xf "SSBI_WRAPPER_SSBI_BYPASS (at 0x8001800c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   OVR_VALUE                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   OVR_MODE                       = " "0,1 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_RD"
   group.long 0x10--0x13 "SSBI_WRAPPER_SSBI_RD (at 0x80018010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19--0x19 "  [   25]   USE_ENABLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   RDWRN                          = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REG_ADD                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   REG_DATA                       = "
  tree.end
  tree "SSBI_WRAPPER_SSBI_STATUS"
   group.long 0x14--0x17 "SSBI_WRAPPER_SSBI_STATUS (at 0x80018014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SSBI_DATA_IN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RD_CLOBBERED                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RD_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   READY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MCHN_BUSY                      = " "0,1 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_PRIORITIES"
   group.long 0x18--0x1b "SSBI_WRAPPER_SSBI_PRIORITIES (at 0x80018018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   PRIORITY2                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   PRIORITY1                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PRIORITY0                      = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_INTR_MASK"
   group.long 0x28--0x2b "SSBI_WRAPPER_SSBI_INTR_MASK (at 0x80018028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SSBI_INTR_MASK                 = " "0,1 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_INTR_CLEAR"
   group.long 0x2c--0x2f "SSBI_WRAPPER_SSBI_INTR_CLEAR (at 0x8001802c)   (shadowed - Use hwio_shadow_ptr->SSBI_WRAPPER_SSBI_INTR_CLEAR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SSBI_INTR_CLEAR                = " "0,1 "
  tree.end
  tree "SSBI_WRAPPER_SSBI_INTR_STATUS"
   group.long 0x30--0x33 "SSBI_WRAPPER_SSBI_INTR_STATUS (at 0x80018030)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SSBI_INTR_STATUS               = " "0,1 "
  tree.end
tree.end

base ad:0x90001200
tree "SVD"
  tree "VD_RESET"
   group.long 0x0--0x3 "VD_RESET (at 0x90001200)   (shadowed - Use hwio_shadow_ptr->VD_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "VD_MODE"
   group.long 0x4--0x7 "VD_MODE (at 0x90001204)   (shadowed - Use hwio_shadow_ptr->VD_MODE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   FLUSH                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   INITMODE                       = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PACKET                         = " "0,1 "
  tree.end
  tree "VD_POLY2IJ"
   group.long 0x8--0xb "VD_POLY2IJ (at 0x90001208)   (shadowed - Use hwio_shadow_ptr->VD_POLY2IJ to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   POLY2J                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   POLY2I                         = "
  tree.end
  tree "VD_POLY3IJ"
   group.long 0xc--0xf "VD_POLY3IJ (at 0x9000120c)   (shadowed - Use hwio_shadow_ptr->VD_POLY3IJ to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   POLY3J                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   POLY3I                         = "
  tree.end
  tree "VD_POLY3K"
   group.long 0x10--0x13 "VD_POLY3K (at 0x90001210)   (shadowed - Use hwio_shadow_ptr->VD_POLY3K to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   POLY3K                         = "
  tree.end
  tree "VD_POLY4IJ"
   group.long 0x14--0x17 "VD_POLY4IJ (at 0x90001214)   (shadowed - Use hwio_shadow_ptr->VD_POLY4IJ to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   POLY4J                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   POLY4I                         = "
  tree.end
  tree "VD_POLY4KL"
   group.long 0x18--0x1b "VD_POLY4KL (at 0x90001218)   (shadowed - Use hwio_shadow_ptr->VD_POLY4KL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x7--0xd 1 "  [13: 7]   POLY4L                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   POLY4K                         = "
  tree.end
  tree "VD_TESTCON"
   group.long 0x1c--0x1f "VD_TESTCON (at 0x9000121c)   (shadowed - Use hwio_shadow_ptr->VD_TESTCON to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEST_CONTROL                   = " "0,1,2,3 "
  tree.end
  tree "VD_TESTOUT"
   group.long 0x20--0x23 "VD_TESTOUT (at 0x90001220)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TESTOUT                        = "
  tree.end
  tree "VD_TEST_MEM_SEL"
   group.long 0x24--0x27 "VD_TEST_MEM_SEL (at 0x90001224)   (shadowed - Use hwio_shadow_ptr->VD_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   SLICE_SEL                      = " "0 (SELECT_RAM_DOUT_15_0),1 (SELECT_RAM_DOUT_31_16),2 (SELECT_RAM_DOUT_47_32),3 (SELECT_RAM_DOUT_63_48) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DN_UP_N                        = " "0 (ADDRESS_INCREASE),1 (ADDRESS_DECREASE) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TST_EN_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TST_SEL_ALL                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RAM_SEL                        = "
  tree.end
  tree "VD_TEST_MEM_ADDR"
   group.long 0x28--0x2b "VD_TEST_MEM_ADDR (at 0x90001228)   (shadowed - Use hwio_shadow_ptr->VD_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   TEST_MEM_ADDR                  = "
  tree.end
  tree "VD_TEST_MEM_WRITE"
   group.long 0x2c--0x2f "VD_TEST_MEM_WRITE (at 0x9000122c)   (shadowed - Use hwio_shadow_ptr->VD_TEST_MEM_WRITE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_WRITE                 = "
  tree.end
  tree "VD_TEST_MEM_READ0"
   group.long 0x30--0x33 "VD_TEST_MEM_READ0 (at 0x90001230)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_READ0                 = "
  tree.end
  tree "VD_TEST_MEM_READ1"
   group.long 0x34--0x37 "VD_TEST_MEM_READ1 (at 0x90001234)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   TEST_MEM_READ0                 = "
  tree.end
  tree "VD_TEST_MEM_DIN"
   group.long 0x38--0x3b "VD_TEST_MEM_DIN (at 0x90001238)   (shadowed - Use hwio_shadow_ptr->VD_TEST_MEM_DIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   TEST_MEM_DIN                   = "
  tree.end
  tree "VD_HW_CLK_CTL"
   group.long 0x3c--0x3f "VD_HW_CLK_CTL (at 0x9000123c)   (shadowed - Use hwio_shadow_ptr->VD_HW_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VD_HW_LCG_EN                   = " "0,1 "
  tree.end
  tree "VD_MICRO_CLK_CTL"
   group.long 0x40--0x43 "VD_MICRO_CLK_CTL (at 0x90001240)   (shadowed - Use hwio_shadow_ptr->VD_MICRO_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VD_MICRO_CLK_EN                = " "0,1 "
  tree.end
  tree "VD_CLK_STATUS"
   group.long 0x44--0x47 "VD_CLK_STATUS (at 0x90001244)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VD_CLK_IS_OFF                  = " "0,1 "
  tree.end
  tree "VD_SPARE_READ_REG0"
   group.long 0x48--0x4b "VD_SPARE_READ_REG0 (at 0x90001248) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   VD_SPARE_READ_REG0             = "
  tree.end
tree.end

base ad:0x8002c000
tree "SYS_MPU"
  tree "SYS_MPU_ENABLE"
   group.long 0x0--0x3 "SYS_MPU_ENABLE (at 0x8002c000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EN                             = " "0,1 "
  tree.end
  tree "SYS_MPU_ERR_STATS"
   group.long 0x4--0x7 "SYS_MPU_ERR_STATS (at 0x8002c004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   BUS_REQ_ADDR                   = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BUS_REQ_MID                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x1--0x4 1 "  [ 4: 1]   BUS_REQ_SID                    = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   BUS_REQ_TYPE                   = " "0,1 "
  tree.end
  tree "SYS_MPU_DEF_PART_PERM0"
   group.long 0x8--0xb "SYS_MPU_DEF_PART_PERM0 (at 0x8002c008) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (RESERVED_PROGRAMMING),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
 tree "SYS_MPU_PART_START_ADDRa"
  tree "SYS_MPU_PART_START_ADDR0"
   group.long 0x20--0x23 "SYS_MPU_PART_START_ADDR0 (at 0x8002c020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_START_ADDR1"
   group.long 0x40--0x43 "SYS_MPU_PART_START_ADDR1 (at 0x8002c040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_START_ADDR2"
   group.long 0x60--0x63 "SYS_MPU_PART_START_ADDR2 (at 0x8002c060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_START_ADDR3"
   group.long 0x80--0x83 "SYS_MPU_PART_START_ADDR3 (at 0x8002c080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
 tree.end
 tree "SYS_MPU_PART_END_ADDRa"
  tree "SYS_MPU_PART_END_ADDR0"
   group.long 0x24--0x27 "SYS_MPU_PART_END_ADDR0 (at 0x8002c024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_END_ADDR1"
   group.long 0x44--0x47 "SYS_MPU_PART_END_ADDR1 (at 0x8002c044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_END_ADDR2"
   group.long 0x64--0x67 "SYS_MPU_PART_END_ADDR2 (at 0x8002c064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
  tree "SYS_MPU_PART_END_ADDR3"
   group.long 0x84--0x87 "SYS_MPU_PART_END_ADDR3 (at 0x8002c084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x16--0x1f 1 "  [31:22]   PART_ADDR_START                = "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   RESERVED_BITS21_0              = "
  tree.end
 tree.end
 tree "SYS_MPU_PART_PERM0a"
  tree "SYS_MPU_PART_PERM00"
   group.long 0x28--0x2b "SYS_MPU_PART_PERM00 (at 0x8002c028) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "SYS_MPU_PART_PERM01"
   group.long 0x48--0x4b "SYS_MPU_PART_PERM01 (at 0x8002c048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "SYS_MPU_PART_PERM02"
   group.long 0x68--0x6b "SYS_MPU_PART_PERM02 (at 0x8002c068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
  tree "SYS_MPU_PART_PERM03"
   group.long 0x88--0x8b "SYS_MPU_PART_PERM03 (at 0x8002c088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ID_2                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ID_1                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ID_0                           = " "0 (NO_ACCESS),1 (READ_ONLY),2 (WRITE_ONLY),3 (READ_AND_WRITE) "
  tree.end
 tree.end
tree.end

base ad:0x90001100
tree "TD"
  tree "TD_ENERGY_METRIC"
   group.long 0x4--0x7 "TD_ENERGY_METRIC (at 0x90001104)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   ENERGY_METRIC                  = "
  tree.end
  tree "TD_STATUS"
   group.long 0x8--0xb "TD_STATUS (at 0x90001108)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0x12 1 "  [18: 8]   MIN_LLR                        = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ITERATIONS_RUN                 = "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   CRC_PASS                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DONE                           = " "0,1 "
  tree.end
  tree "TD_TEST_MEM_SEL"
   group.long 0xc--0xf "TD_TEST_MEM_SEL (at 0x9000110c)   (shadowed - Use hwio_shadow_ptr->TD_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   SLICE_SEL                      = " "0 (SELECT_RAM_DOUT_15_0),1 (SELECT_RAM_DOUT_31_16),2 (SELECT_RAM_DOUT_47_32),3 (SELECT_RAM_DOUT_63_48),4 (SELECT_RAM_DOUT_79_64),5 (reserved),6 (reserved),7 (WL_32) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DN_UP_N                        = " "0 (ADDRESS_INCREASE),1 (ADDRESS_DECREASE) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TST_EN_N                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   TST_SEL_ALL                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   RAM_SEL                        = "
  tree.end
  tree "TD_TEST_MEM_ADDR"
   group.long 0x10--0x13 "TD_TEST_MEM_ADDR (at 0x90001110)   (shadowed - Use hwio_shadow_ptr->TD_TEST_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   TEST_MEM_ADDR                  = "
  tree.end
  tree "TD_TEST_MEM_WRITE"
   group.long 0x14--0x17 "TD_TEST_MEM_WRITE (at 0x90001114)   (shadowed - Use hwio_shadow_ptr->TD_TEST_MEM_WRITE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_MEM_WRITE                 = " "0,1 "
  tree.end
  tree "TD_TEST_MEM_READ0"
   group.long 0x1c--0x1f "TD_TEST_MEM_READ0 (at 0x9000111c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_READ0                 = "
  tree.end
  tree "TD_TEST_MEM_READ1"
   group.long 0x20--0x23 "TD_TEST_MEM_READ1 (at 0x90001120)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_READ2                 = "
  tree.end
  tree "TD_TEST_MEM_READ2"
   group.long 0x24--0x27 "TD_TEST_MEM_READ2 (at 0x90001124)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_MEM_READ2                 = "
  tree.end
  tree "TD_TEST_MEM_DIN"
   group.long 0x28--0x2b "TD_TEST_MEM_DIN (at 0x90001128)   (shadowed - Use hwio_shadow_ptr->TD_TEST_MEM_DIN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_MEM_DIN                   = "
  tree.end
  tree "HDR_DDI_CTL"
   group.long 0x2c--0x2f "HDR_DDI_CTL (at 0x9000112c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DDI_HOST_MODE                  = " "0,1 "
  tree.end
  tree "HDR_DDI_HOST"
   group.long 0x30--0x33 "HDR_DDI_HOST (at 0x90001130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   DDI_READY                      = " "0 (DDI_NOT_READY),1 (DDI_READY) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   DDI_EOF                        = " "0 (NOT_EOF),1 (EOF) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DDI_DATA                       = "
  tree.end
  tree "TD_HW_CLK_CTL"
   group.long 0x34--0x37 "TD_HW_CLK_CTL (at 0x90001134)   (shadowed - Use hwio_shadow_ptr->TD_HW_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TD_HW_LCG_EN                   = " "0,1 "
  tree.end
  tree "TD_MICRO_CLK_CTL"
   group.long 0x38--0x3b "TD_MICRO_CLK_CTL (at 0x90001138)   (shadowed - Use hwio_shadow_ptr->TD_MICRO_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TD_MICRO_CLK_EN                = " "0,1 "
  tree.end
  tree "TD_CLK_STATUS"
   group.long 0x3c--0x3f "TD_CLK_STATUS (at 0x9000113c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TD_CLK_IS_OFF                  = " "0,1 "
  tree.end
  tree "TD_MISC_CTL"
   group.long 0x40--0x43 "TD_MISC_CTL (at 0x90001140)   (shadowed - Use hwio_shadow_ptr->TD_MISC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   TDWRAPPER_SW_RESET             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_TD_ABORT                = " "0,1 "
  tree.end
  tree "TD_ONE_FIFTH_TAIL_PATTERN"
   group.long 0x44--0x47 "TD_ONE_FIFTH_TAIL_PATTERN (at 0x90001144)   (shadowed - Use hwio_shadow_ptr->TD_ONE_FIFTH_TAIL_PATTERN to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TAIL_PATTERN                   = "
  tree.end
  tree "TD_TAIL_CFG"
   group.long 0x48--0x4b "TD_TAIL_CFG (at 0x90001148)   (shadowed - Use hwio_shadow_ptr->TD_TAIL_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   REGULAR_SYM_BYPASS             = " "0,1 "
  tree.end
  tree "TD_MODE_CTL"
   group.long 0x4c--0x4f "TD_MODE_CTL (at 0x9000114c)   (shadowed - Use hwio_shadow_ptr->TD_MODE_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TD_SEL                         = " "0,1 "
  tree.end
tree.end

base ad:0xf0000000
tree "TOP_UART"
  tree "UART_DM_MR1"
   group.long 0x0--0x3 "UART_DM_MR1 (at 0xf0000000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x8--0x1f 1 "  [31: 8]   AUTO_RFR_LEVEL1                = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RX_RDY_CTL                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CTS_CTL                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   AUTO_RFR_LEVEL0                = "
  tree.end
  tree "UART_DM_MR2"
   group.long 0x4--0x7 "UART_DM_MR2 (at 0xf0000004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LOOPBACK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_MODE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BITS_PER_CHAR                  = " "0 (5_BITS),1 (6_BITS),2 (7_BITS),3 (8_BITS) "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   STOP_BIT_LEN                   = " "0 (0_563),1 (1_000_BIT_TIME),2 (1_563),3 (2_000_BIT_TIMES) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PARITY_MODE                    = " "0 (NO_PARITY),1 (ODD_PARITY),2 (EVEN_PARITY),3 (SPACE_PARITY) "
  tree.end
  tree "UART_DM_CSR"
   group.long 0x8--0xb "UART_DM_CSR (at 0xf0000008)   (shadowed - Use hwio_shadow_ptr->UART_DM_CSR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UART_RX_CLK_SEL                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   UART_TX_CLK_SEL                = "
  tree.end
  tree "UART_DM_TF"
   group.long 0x70--0x73 "UART_DM_TF (at 0xf0000070)   (shadowed - Use hwio_shadow_ptr->UART_DM_TF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "UART_DM_TF_2"
   group.long 0x74--0x77 "UART_DM_TF_2 (at 0xf0000074)   (shadowed - Use hwio_shadow_ptr->UART_DM_TF_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "UART_DM_TF_3"
   group.long 0x78--0x7b "UART_DM_TF_3 (at 0xf0000078)   (shadowed - Use hwio_shadow_ptr->UART_DM_TF_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "UART_DM_TF_4"
   group.long 0x7c--0x7f "UART_DM_TF_4 (at 0xf000007c)   (shadowed - Use hwio_shadow_ptr->UART_DM_TF_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_TF                        = "
  tree.end
  tree "UART_DM_CR"
   group.long 0x10--0x13 "UART_DM_CR (at 0xf0000010)   (shadowed - Use hwio_shadow_ptr->UART_DM_CR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   CHANNEL_COMMAND_MSB            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GENERAL_COMMAND                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHANNEL_COMMAND_LSB            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   UART_TX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   UART_TX_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   UART_RX_DISABLE                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   UART_RX_EN                     = " "0,1 "
  tree.end
  tree "UART_DM_IMR"
   group.long 0x14--0x17 "UART_DM_IMR (at 0xf0000014)   (shadowed - Use hwio_shadow_ptr->UART_DM_IMR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "UART_DM_IPR"
   group.long 0x18--0x1b "UART_DM_IPR (at 0xf0000018) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x7--0x1f 1 "  [31: 7]   STALE_TIMEOUT_MSB              = "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   SAMPLE_DATA                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STALE_TIMEOUT_LSB              = "
  tree.end
  tree "UART_DM_TFWR"
   group.long 0x1c--0x1f "UART_DM_TFWR (at 0xf000001c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TFW                            = "
  tree.end
  tree "UART_DM_RFWR"
   group.long 0x20--0x23 "UART_DM_RFWR (at 0xf0000020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   RFW                            = "
  tree.end
  tree "UART_DM_HCR"
   group.long 0x24--0x27 "UART_DM_HCR (at 0xf0000024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                           = "
  tree.end
  tree "UART_DM_DMRX"
   group.long 0x34--0x37 "UART_DM_DMRX (at 0xf0000034) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   RX_DM_CRCI_CHARS               = "
  tree.end
  tree "UART_DM_IRDA"
   group.long 0x38--0x3b "UART_DM_IRDA (at 0xf0000038)   (shadowed - Use hwio_shadow_ptr->UART_DM_IRDA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   MEDIUM_RATE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   IRDA_LOOPBACK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   INVERT_IRDA_TX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INVERT_IRDA_RX                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   IRDA_EN                        = " "0,1 "
  tree.end
  tree "UART_DM_DMEN"
   group.long 0x3c--0x3f "UART_DM_DMEN (at 0xf000003c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RX_DM_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DM_EN                       = " "0,1 "
  tree.end
  tree "UART_DM_NO_CHARS_FOR_TX"
   group.long 0x40--0x43 "UART_DM_NO_CHARS_FOR_TX (at 0xf0000040) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   TX_TOTAL_TRANS_LEN             = "
  tree.end
  tree "UART_DM_BADR"
   group.long 0x44--0x47 "UART_DM_BADR (at 0xf0000044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RX_BASE_ADDR                   = "
  tree.end
  tree "UART_DM_TESTSL"
   group.long 0x48--0x4b "UART_DM_TESTSL (at 0xf0000048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TEST_EN                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_SEL                       = "
  tree.end
  tree "UART_DM_MISR_MODE"
   group.long 0x60--0x63 "UART_DM_MISR_MODE (at 0xf0000060) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                           = " "0 (DISABLED),1 (ENABLED_TX_TEST),2 (ENABLED_RX_TEST),3 (reserved) "
  tree.end
  tree "UART_DM_MISR_RESET"
   group.long 0x64--0x67 "UART_DM_MISR_RESET (at 0xf0000064) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "UART_DM_MISR_EXPORT"
   group.long 0x68--0x6b "UART_DM_MISR_EXPORT (at 0xf0000068) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EXPORT                         = " "0,1 "
  tree.end
  tree "UART_DM_MISR_VAL"
   group.long 0x6c--0x6f "UART_DM_MISR_VAL (at 0xf000006c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   VAL                            = "
  tree.end
  tree "UART_DM_SIM_CFG"
   group.long 0x80--0x83 "UART_DM_SIM_CFG (at 0xf0000080)   (shadowed - Use hwio_shadow_ptr->UART_DM_SIM_CFG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   UIM_TX_MODE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   UIM_RX_MODE                    = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SIM_STOP_BIT_LEN               = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   SIM_CLK_ON                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SIM_CLK_TD8_SEL                = " "0 (TD4),1 (TD8) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   SIM_CLK_STOP_HIGH              = " "0 (LOW),1 (HIGH) "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SIM_CLK_SEL                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_RX                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SWAP_D                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   INV_D                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SIM_SEL                        = " "0,1 "
  tree.end
  tree "UART_DM_TEST_WR_ADDR"
   group.long 0x84--0x87 "UART_DM_TEST_WR_ADDR (at 0xf0000084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_ADDR                   = "
  tree.end
  tree "UART_DM_TEST_WR_DATA"
   group.long 0x88--0x8b "UART_DM_TEST_WR_DATA (at 0xf0000088)   (shadowed - Use hwio_shadow_ptr->UART_DM_TEST_WR_DATA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_WR_DATA                   = "
  tree.end
  tree "UART_DM_TEST_RD_ADDR"
   group.long 0x8c--0x8f "UART_DM_TEST_RD_ADDR (at 0xf000008c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_ADDR                   = "
  tree.end
  tree "UART_DM_SR"
   group.long 0x8--0xb "UART_DM_SR (at 0xf0000008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   HUNT_CHAR                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RX_BREAK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PAR_FRAME_ERR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   UART_OVERRUN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TXEMT                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TXRDY                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXFULL                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RXRDY                          = " "0,1 "
  tree.end
  tree "UART_DM_RF"
   group.long 0x70--0x73 "UART_DM_RF (at 0xf0000070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "UART_DM_RF_2"
   group.long 0x74--0x77 "UART_DM_RF_2 (at 0xf0000074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "UART_DM_RF_3"
   group.long 0x78--0x7b "UART_DM_RF_3 (at 0xf0000078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "UART_DM_RF_4"
   group.long 0x7c--0x7f "UART_DM_RF_4 (at 0xf000007c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   UART_RF                        = "
  tree.end
  tree "UART_DM_MISR"
   group.long 0x10--0x13 "UART_DM_MISR (at 0xf0000010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   UART_MISR                      = "
  tree.end
  tree "UART_DM_ISR"
   group.long 0x14--0x17 "UART_DM_ISR (at 0xf0000014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   TX_DONE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TX_ERROR                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_READY                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CURRENT_CTS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   DELTA_CTS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RXLEV                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RXSTALE                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   RXBREAK                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RXHUNT                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TXLEV                          = " "0,1 "
  tree.end
  tree "UART_DM_RX_TOTAL_SNAP"
   group.long 0x38--0x3b "UART_DM_RX_TOTAL_SNAP (at 0xf0000038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   RX_TOTAL_BYTES                 = "
  tree.end
  tree "UART_DM_TXFS"
   group.long 0x4c--0x4f "UART_DM_TXFS (at 0xf000004c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   TX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   TX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TX_FIFO_STATE_LSB              = "
  tree.end
  tree "UART_DM_RXFS"
   group.long 0x50--0x53 "UART_DM_RXFS (at 0xf0000050)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RX_FIFO_STATE_MSB              = "
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   RX_BUFFER_STATE                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RX_FIFO_STATE_LSB              = "
  tree.end
  tree "UART_DM_TEST_RD_DATA"
   group.long 0x90--0x93 "UART_DM_TEST_RD_DATA (at 0xf0000090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TEST_RD_DATA                   = "
  tree.end
tree.end
tree "UNUSED"
base ad:0x90005000
tree "UNUSED_EDGE"
  tree "UNUSED_MICRO_GSM_TIME_RD"
   group.long 0x0--0x3 "UNUSED_MICRO_GSM_TIME_RD (at 0x90005000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   ODD_FRAME                      = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x6--0x11 1 "  [17: 6]   SYMBOL_TIME                    = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   Q_SYMBOL_TIME                  = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PRESCALE_TIME                  = "
  tree.end
  tree "UNUSED_MICRO_IRQ_CONFIG_RW"
   group.long 0x4--0x7 "UNUSED_MICRO_IRQ_CONFIG_RW (at 0x90005004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   MICRO_IRQ_MSB_IGNORE           = "
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   MIRCO_IRQ_ENA                  = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   MICRO_IRQ_TIME                 = "
  tree.end
  tree "UNUSED_GSM_TIME_LOAD_CTL_CMD"
   group.long 0x8--0xb "UNUSED_GSM_TIME_LOAD_CTL_CMD (at 0x90005008)   (shadowed - Use hwio_shadow_ptr->UNUSED_GSM_TIME_LOAD_CTL_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   GSM_TIME_CNT_SEL               = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   GSM_TIME_LOAD_VALUE            = "
  tree.end
  tree "UNUSED_GSM_TIME_TC_ADJ_CMD"
   group.long 0xc--0xf "UNUSED_GSM_TIME_TC_ADJ_CMD (at 0x9000500c)   (shadowed - Use hwio_shadow_ptr->UNUSED_GSM_TIME_TC_ADJ_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x13 "  [   19]   ORIDE_TC                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   UNUSED_BIT18                   = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x11 1 "  [17: 0]   GSM_TIME_TC_VALUE              = "
  tree.end
  tree "UNUSED_VFR_IRQ_ALIGN_CMD"
   group.long 0x10--0x13 "UNUSED_VFR_IRQ_ALIGN_CMD (at 0x90005010)   (shadowed - Use hwio_shadow_ptr->UNUSED_VFR_IRQ_ALIGN_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   VRF_IRQ_FRAME_ALIGN            = " "0,1 "
  tree.end
  tree "UNUSED_ENABLE_GSTMR_DURING_SLEEP"
   group.long 0x14--0x17 "UNUSED_ENABLE_GSTMR_DURING_SLEEP (at 0x90005014) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GSTMR_DURING_SLEEP_ENA         = " "0,1 "
  tree.end
  tree "UNUSED_GO_TO_SLEEP_CMD"
   group.long 0x18--0x1b "UNUSED_GO_TO_SLEEP_CMD (at 0x90005018)   (shadowed - Use hwio_shadow_ptr->UNUSED_GO_TO_SLEEP_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GEN_GO_TO_SLEEP                = " "0,1 "
  tree.end
  tree "UNUSED_GSM_CORE_MICRO_RESET_REG"
   group.long 0x1c--0x1f "UNUSED_GSM_CORE_MICRO_RESET_REG (at 0x9000501c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   RESET_EDGETXCLK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESET_EDGERXCLK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESET_ENCRYPTCLK               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RESET_MDSPCLK                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_GSMCLK                   = " "0,1 "
  tree.end
  tree "UNUSED_TEST_PT_CTL_RW"
   group.long 0x20--0x23 "UNUSED_TEST_PT_CTL_RW (at 0x90005020) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TEST_PT_BLK_SEL                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_PT_BUS_SEL                = "
  tree.end
  tree "UNUSED_GSM_DSP_WR_CLK_CTL"
   group.long 0x24--0x27 "UNUSED_GSM_DSP_WR_CLK_CTL (at 0x90005024) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GSM_DSP_WR_CLK_OVERRIDE        = " "0,1 "
  tree.end
  tree "UNUSED_GSM_HYPERFRAME_LOAD_CTL_CMD"
   group.long 0x28--0x2b "UNUSED_GSM_HYPERFRAME_LOAD_CTL_CMD (at 0x90005028)   (shadowed - Use hwio_shadow_ptr->UNUSED_GSM_HYPERFRAME_LOAD_CTL_CMD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x16 "  [   22]   HYPERFRAME_LOAD_EN             = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   HYPERFRAME_LOAD_VALUE          = "
  tree.end
  tree "UNUSED_GSM_FRAME_COUNT_RD"
   group.long 0x2c--0x2f "UNUSED_GSM_FRAME_COUNT_RD (at 0x9000502c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   CUR_FRAME_COUNT                = "
  tree.end
  tree "UNUSED_EDGE_CGC_ENA"
   group.long 0x30--0x33 "UNUSED_EDGE_CGC_ENA (at 0x90005030) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   MDSP_CGC_CTL_ENABLE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   EDGE_ENCRYPT_GEA_CLK_EN        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   EDGE_ENCRYPT_A5_CLK_EN         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   EDGE_TX_EER_CLK_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   EDGE_TX_EMOD_CLK_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   EDGE_RX_EACS_CLK_EN            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   EDGE_RX_EEQ_CLK_EN             = " "0,1 "
  tree.end
  tree "UNUSED_GSM_TIME_SYNC_CTL"
   group.long 0x34--0x37 "UNUSED_GSM_TIME_SYNC_CTL (at 0x90005034)   (shadowed - Use hwio_shadow_ptr->UNUSED_GSM_TIME_SYNC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   ON_LINE_LOAD_EN                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   GPS_CAPTURE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   WCDMA_CAPTURE_EN               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ON_LINE_START_SEL              = " "0,1 "
  tree.end
  tree "UNUSED_GSM_TIME_ON_LINE"
   group.long 0x38--0x3b "UNUSED_GSM_TIME_ON_LINE (at 0x90005038)   (shadowed - Use hwio_shadow_ptr->UNUSED_GSM_TIME_ON_LINE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   GSM_TIME_ON_LINE               = "
  tree.end
  tree "UNUSED_GSM_WCDMA_SYNC_TIME"
   group.long 0x3c--0x3f "UNUSED_GSM_WCDMA_SYNC_TIME (at 0x9000503c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   WCDMA_SYNC_TIME                = "
  tree.end
  tree "UNUSED_GSM_GPS_SYNC_TIME"
   group.long 0x40--0x43 "UNUSED_GSM_GPS_SYNC_TIME (at 0x90005040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   GPS_SYNC_TIME                  = "
  tree.end
  tree "UNUSED_GEA_CONFIG_0"
   group.long 0x44--0x47 "UNUSED_GEA_CONFIG_0 (at 0x90005044) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   GEA12_BIG_ENDIAN               = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   GEA12_PREPEND_X_ZEROS          = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   GEA_DIRECTION_DATA_BIT         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GEA_SHIFT_INTO_MSB_ENA         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   GEA12_KEY_STREAM_GEN_CMD       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   GEA12_AUTOGEN_ENA              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   GEA12_32OCTETS_MODE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   GEA_MODE                       = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   GEA_TRIGGER                    = " "0,1 "
  tree.end
  tree "UNUSED_GEA_INPUT"
   group.long 0x48--0x4b "UNUSED_GEA_INPUT (at 0x90005048) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   FRAME_DEPENDENT_INPUT          = "
  tree.end
 tree "GEA_KC_n"
  tree "UNUSED_GEA_KC_0"
   group.long 0x4c--0x4f "UNUSED_GEA_KC_0 (at 0x9000504c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
  tree "UNUSED_GEA_KC_1"
   group.long 0x50--0x53 "UNUSED_GEA_KC_1 (at 0x90005050) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
  tree "UNUSED_GEA_KC_2"
   group.long 0x54--0x57 "UNUSED_GEA_KC_2 (at 0x90005054) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
  tree "UNUSED_GEA_KC_3"
   group.long 0x58--0x5b "UNUSED_GEA_KC_3 (at 0x90005058) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
 tree.end
  tree "UNUSED_GEA34_KS_LENGTH"
   group.long 0x5c--0x5f "UNUSED_GEA34_KS_LENGTH (at 0x9000505c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   KEY_STREAM_LENGTH              = "
  tree.end
  tree "UNUSED_GEA34_STATUS"
   group.long 0x60--0x63 "UNUSED_GEA34_STATUS (at 0x90005060)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x3--0xa 1 "  [10: 3]   GEA34_KG_BLKCNT                = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   GEA34_IDLE                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_FILLED                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   FIFO_EMPTY                     = " "0,1 "
  tree.end
  tree "UNUSED_GEA34_KEY_STRM_DOUT"
   group.long 0x64--0x67 "UNUSED_GEA34_KEY_STRM_DOUT (at 0x90005064)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEYSTREAM                      = "
  tree.end
 tree "AMBA_KEY_STRM_WORDn_RD"
  tree "UNUSED_AMBA_KEY_STRM_WORD0_RD"
   group.long 0x68--0x6b "UNUSED_AMBA_KEY_STRM_WORD0_RD (at 0x90005068)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD1_RD"
   group.long 0x6c--0x6f "UNUSED_AMBA_KEY_STRM_WORD1_RD (at 0x9000506c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD2_RD"
   group.long 0x70--0x73 "UNUSED_AMBA_KEY_STRM_WORD2_RD (at 0x90005070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD3_RD"
   group.long 0x74--0x77 "UNUSED_AMBA_KEY_STRM_WORD3_RD (at 0x90005074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD4_RD"
   group.long 0x78--0x7b "UNUSED_AMBA_KEY_STRM_WORD4_RD (at 0x90005078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD5_RD"
   group.long 0x7c--0x7f "UNUSED_AMBA_KEY_STRM_WORD5_RD (at 0x9000507c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD6_RD"
   group.long 0x80--0x83 "UNUSED_AMBA_KEY_STRM_WORD6_RD (at 0x90005080)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
  tree "UNUSED_AMBA_KEY_STRM_WORD7_RD"
   group.long 0x84--0x87 "UNUSED_AMBA_KEY_STRM_WORD7_RD (at 0x90005084)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   GEA12_KEYSTREAM                = "
  tree.end
 tree.end
  tree "UNUSED_AMBA_KEY_STRM_STATUS"
   group.long 0x88--0x8b "UNUSED_AMBA_KEY_STRM_STATUS (at 0x90005088)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   GEA12_ACTIVE                   = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x8--0x1e 1 "  [30: 8]   UNUSED_BITS                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   GEA12_STATUS                   = "
  tree.end
  tree "UNUSED_AFIVE12_CONFIG_0"
   group.long 0x8c--0x8f "UNUSED_AFIVE12_CONFIG_0 (at 0x9000508c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   CONTINUE_2NDBLK                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   MDSP_EN                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   BLK_IDX_CFG                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BLK_SIZE_CFG                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   A52_MODE                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   AFIVE12_ARM                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   AFIVE12_GO                     = " "0,1 "
  tree.end
  tree "UNUSED_AFIVE12_INPUT"
   group.long 0x90--0x93 "UNUSED_AFIVE12_INPUT (at 0x90005090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x15 1 "  [21: 0]   INPUT                          = "
  tree.end
 tree "AFIVE12_KC_n"
  tree "UNUSED_AFIVE12_KC_0"
   group.long 0x94--0x97 "UNUSED_AFIVE12_KC_0 (at 0x90005094) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
  tree "UNUSED_AFIVE12_KC_1"
   group.long 0x98--0x9b "UNUSED_AFIVE12_KC_1 (at 0x90005098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   CIPHER_KEY                     = "
  tree.end
 tree.end
 tree "AFIVE_KEY_STRM_WORDn_RD"
  tree "UNUSED_AFIVE_KEY_STRM_WORD0_RD"
   group.long 0xa0--0xa3 "UNUSED_AFIVE_KEY_STRM_WORD0_RD (at 0x900050a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD1_RD"
   group.long 0xa4--0xa7 "UNUSED_AFIVE_KEY_STRM_WORD1_RD (at 0x900050a4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD2_RD"
   group.long 0xa8--0xab "UNUSED_AFIVE_KEY_STRM_WORD2_RD (at 0x900050a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD3_RD"
   group.long 0xac--0xaf "UNUSED_AFIVE_KEY_STRM_WORD3_RD (at 0x900050ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD4_RD"
   group.long 0xb0--0xb3 "UNUSED_AFIVE_KEY_STRM_WORD4_RD (at 0x900050b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD5_RD"
   group.long 0xb4--0xb7 "UNUSED_AFIVE_KEY_STRM_WORD5_RD (at 0x900050b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD6_RD"
   group.long 0xb8--0xbb "UNUSED_AFIVE_KEY_STRM_WORD6_RD (at 0x900050b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD7_RD"
   group.long 0xbc--0xbf "UNUSED_AFIVE_KEY_STRM_WORD7_RD (at 0x900050bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD8_RD"
   group.long 0xc0--0xc3 "UNUSED_AFIVE_KEY_STRM_WORD8_RD (at 0x900050c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD9_RD"
   group.long 0xc4--0xc7 "UNUSED_AFIVE_KEY_STRM_WORD9_RD (at 0x900050c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
  tree "UNUSED_AFIVE_KEY_STRM_WORD10_RD"
   group.long 0xc8--0xcb "UNUSED_AFIVE_KEY_STRM_WORD10_RD (at 0x900050c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   KEY_STREAM_BLOCK               = "
  tree.end
 tree.end
  tree "UNUSED_ENCRYPT_MICRO_IRQ_CONFIG"
   group.long 0xcc--0xcf "UNUSED_ENCRYPT_MICRO_IRQ_CONFIG (at 0x900050cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DONE_IRQ_CLEAR                 = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DONE_IRQ_ENABLE                = " "0,1,2,3 "
  tree.end
  tree "UNUSED_ENCRYPT_MICRO_IRQ_STATUS"
   group.long 0xd0--0xd3 "UNUSED_ENCRYPT_MICRO_IRQ_STATUS (at 0x900050d0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   GEA_IRQ_STATUS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   A5_IRQ_STATUS                  = " "0,1 "
  tree.end
  tree "UNUSED_PADAC_DIN_TEST"
   group.long 0xd4--0xd7 "UNUSED_PADAC_DIN_TEST (at 0x900050d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   PADAC_DIN_TEST_EN              = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   PADAC_DIN_TEST_VAL             = "
  tree.end
tree.end

base ad:0x9000a200
tree "UNUSED_GPS_BP"
  tree "UNUSED_TS_MODE"
   group.long 0x0--0x3 "UNUSED_TS_MODE (at 0x9000a200) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xc "  [12:11]   TS_SDMQUANT                    = " "0 (OFF),1 (Q2),2 (Q3),3 (Q4) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   TS_RATE                        = " "0 (FULL),1 (HALF) "
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   TS_LPFSW                       = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x7--0x8 "  [ 8: 7]   TS_DACREF                      = " "0 (100_MV),1 (200_MV),2 (400_MV),3 (800_MV) "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TS_OUTSEL                      = " "0 (OFF),1 (ADC),2 (SDM),3 (CONST) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   TS_SIGNALSW                    = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   TS_NOISESW                     = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TS_CODE                        = " "0 (GEN),1 (CONST) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   TS_MODE                        = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TS_INIT                        = " "0 (NO),1 (YES) "
  tree.end
  tree "UNUSED_TS_FREQL"
   group.long 0x4--0x7 "UNUSED_TS_FREQL (at 0x9000a204) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   TS_FREQL                       = "
  tree.end
  tree "UNUSED_TS_FREQH"
   group.long 0x8--0xb "UNUSED_TS_FREQH (at 0x9000a208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   TS_DCOFFSET                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TS_FREQM                       = "
  tree.end
  tree "UNUSED_TS_TIME_SLIP"
   group.long 0xc--0xf "UNUSED_TS_TIME_SLIP (at 0x9000a20c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TS_TIMESLIP                    = " "0 (ZERO),1 (POS),2 (ZERO2),3 (NEG) "
  tree.end
  tree "UNUSED_TS_DATA"
   group.long 0x10--0x13 "UNUSED_TS_DATA (at 0x9000a210) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   TS_DATA                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TS_TESTSIGQ                    = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TS_TESTSIGI                    = "
  tree.end
  tree "UNUSED_TS_NOISE_PHASE"
   group.long 0x14--0x17 "UNUSED_TS_NOISE_PHASE (at 0x9000a214) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   TS_NOISESEED                   = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TS_PHASE                       = "
  tree.end
  tree "UNUSED_TS_CODE_SEED"
   group.long 0x18--0x1b "UNUSED_TS_CODE_SEED (at 0x9000a218) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   TS_CODESEED                    = "
  tree.end
  tree "UNUSED_TS_PARAMS"
   group.long 0x1c--0x1f "UNUSED_TS_PARAMS (at 0x9000a21c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   TS_SDMAMP                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   TS_MODLEV                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   TS_SNR                         = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   TS_FINEAMP                     = " "0 (ATTEN),1 (PASS) "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TS_AMP                         = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TS_QUANT                       = " "0 (OFF),1 (Q2),2 (Q3),3 (Q4),4 (Q7),5 (Q8),6 (Q15),7 (OFF2) "
  tree.end
  tree "UNUSED_BC_MODE"
   group.long 0x40--0x43 "UNUSED_BC_MODE (at 0x9000a240) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   BC_SAMPLELOG                   = " "0 (I4),1 (Q4),2 (QI2),3 (QI4) "
    textline ""
    bitfld.long 0x0 0xd "  [   13]   BC_SAMPLELOGEN                 = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   BC_BLANKSIG                    = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x5--0xb 1 "  [11: 5]   BC_WAITRTC                     = "
    textline ""
    bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BC_NFRAME                      = " "0 (OFF),1 (ONE),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   BC_BWSEL                       = " "0 (FULL),1 (HALF) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   BC_MODE                        = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BC_INIT                        = " "0 (NO),1 (YES) "
  tree.end
  tree "UNUSED_BC_CONFIG"
   group.long 0x44--0x47 "UNUSED_BC_CONFIG (at 0x9000a244) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   BC_LPFLENGTH                   = " "0 (SIX),1 (NINE) "
    textline ""
    bitfld.long 0x0 0xc--0xe "  [14:12]   BC_GAINSTEP                    = " "0 (OFF),1 (G1),2 (G2),3 (G3),4 (G4),5 (G5),6 (G6),7 (G7) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   BC_BLANKEN                     = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0xa "  [   10]   BC_BLANKPOL                    = " "0 (POS),1 (NEG) "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   BC_QUANTSEL                    = " "0 (SECOND),1 (FOURTH),2 (UNIFORM),3 (AUX) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   BC_QUANTINV                    = " "0 (NO),1 (YES) "
    textline ""
    bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BC_QUANTLEV                    = " "0 (OFFA),1 (Q2A),2 (Q3A),3 (Q4A),4 (Q4M),5 (Q7A),6 (Q8A),7 (Q15A) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   BC_GAINALIGN                   = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   BC_DCALIGN                     = " "0 (OFF),1 (ON) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   BC_RATE                        = " "0 (FULL),1 (HALF) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BC_SRCSEL                      = " "0 (RX),1 (TS) "
  tree.end
  tree "UNUSED_BC_OFFSETI"
   group.long 0x48--0x4b "UNUSED_BC_OFFSETI (at 0x9000a248) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_OFFSETI                     = "
  tree.end
  tree "UNUSED_BP_OFFSETQ"
   group.long 0x4c--0x4f "UNUSED_BP_OFFSETQ (at 0x9000a24c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_OFFSETQ                     = "
  tree.end
  tree "UNUSED_BC_EQCOEF1"
   group.long 0x50--0x53 "UNUSED_BC_EQCOEF1 (at 0x9000a250) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BC_EQCOEF0                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BC_EQCOEF1                     = "
  tree.end
  tree "UNUSED_BC_EQCOEF2"
   group.long 0x54--0x57 "UNUSED_BC_EQCOEF2 (at 0x9000a254) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BC_EQCOEF2                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BC_EQCOEF3                     = "
  tree.end
  tree "UNUSED_BC_FREQL"
   group.long 0x58--0x5b "UNUSED_BC_FREQL (at 0x9000a258) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_FREQL                       = "
  tree.end
  tree "UNUSED_BC_FREQM"
   group.long 0x5c--0x5f "UNUSED_BC_FREQM (at 0x9000a25c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BC_FREQM                       = "
  tree.end
  tree "UNUSED_BC_DELTAFREQ"
   group.long 0x60--0x63 "UNUSED_BC_DELTAFREQ (at 0x9000a260) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   BC_DELTAFREQ                   = "
  tree.end
  tree "UNUSED_BC_THRESHOLD"
   group.long 0x64--0x67 "UNUSED_BC_THRESHOLD (at 0x9000a264) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   BC_THRESHQ                     = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   BC_THRESHI                     = "
  tree.end
  tree "UNUSED_BC_CONFIG2"
   group.long 0x68--0x6b "UNUSED_BC_CONFIG2 (at 0x9000a268) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   BC_RXBYPASS                    = " "0 (NO),1 (YES) "
    textline ""
    hexmask.long.word 0x0 0x4--0xb 1 "  [11: 4]   BC_QUANTREMAP                  = "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   BC_SWAPIQ                      = " "0 (NO),1 (YES) "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   BC_SIGNINVQ                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   BC_SIGNINVI                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   BC_LPFBYPASS                   = " "0 (NO),1 (YES) "
  tree.end
  tree "UNUSED_BC_MEAN_MON_I"
   group.long 0x6c--0x6f "UNUSED_BC_MEAN_MON_I (at 0x9000a26c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_MEANMONI                    = "
  tree.end
  tree "UNUSED_BC_MEAN_MON_Q"
   group.long 0x70--0x73 "UNUSED_BC_MEAN_MON_Q (at 0x9000a270)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_MEANMONQ                    = "
  tree.end
  tree "UNUSED_BC_AMPL_MON_I"
   group.long 0x74--0x77 "UNUSED_BC_AMPL_MON_I (at 0x9000a274)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   BC_AMPLMONI                    = "
  tree.end
  tree "UNUSED_BC_AMPL_MON_Q"
   group.long 0x78--0x7b "UNUSED_BC_AMPL_MON_Q (at 0x9000a278)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   BC_AMPLMONQ                    = "
  tree.end
  tree "UNUSED_BC_BLANK_MON"
   group.long 0x7c--0x7f "UNUSED_BC_BLANK_MON (at 0x9000a27c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   BC_BLANKMON                    = "
  tree.end
  tree "UNUSED_SM_0"
   group.long 0x80--0x83 "UNUSED_SM_0 (at 0x9000a280) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x7--0x9 "  [ 9: 7]   SM_TESTINSEL                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   SM_MODE                        = " "0 (INDIRECT),1 (DIRECT) "
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   SM_PTR1                        = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SM_PTR0                        = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "UNUSED_SM_1"
   group.long 0x84--0x87 "UNUSED_SM_1 (at 0x9000a284)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SM_TSQOUT                      = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SM_TSIOUT                      = "
  tree.end
  tree "UNUSED_SM_2"
   group.long 0x88--0x8b "UNUSED_SM_2 (at 0x9000a288)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   SM_RESET                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   SM_BLANK                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   SM_TSTSTB                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SM_TSFS                        = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SM_BCFS                        = " "0,1 "
  tree.end
  tree "UNUSED_SM_3"
   group.long 0x8c--0x8f "UNUSED_SM_3 (at 0x9000a28c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SM_RXQIN                       = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SM_RXIIN                       = "
  tree.end
  tree "UNUSED_SM_4"
   group.long 0x90--0x93 "UNUSED_SM_4 (at 0x9000a290)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SM_BCQOUT                      = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SM_BCIOUT                      = "
  tree.end
  tree "UNUSED_SM_5"
   group.long 0x94--0x97 "UNUSED_SM_5 (at 0x9000a294)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   SM_AUXQIN                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   SM_AUXIIN                      = "
  tree.end
  tree "UNUSED_SM_6"
   group.long 0x98--0x9b "UNUSED_SM_6 (at 0x9000a298)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SM_TSINQ                       = "
  tree.end
  tree "UNUSED_SM_7"
   group.long 0x9c--0x9f "UNUSED_SM_7 (at 0x9000a29c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SM_TSQNQ                       = "
  tree.end
  tree "UNUSED_SM_8"
   group.long 0xa0--0xa3 "UNUSED_SM_8 (at 0x9000a2a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   SM_BCIFIL                      = "
  tree.end
  tree "UNUSED_SM_9"
   group.long 0xa4--0xa7 "UNUSED_SM_9 (at 0x9000a2a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   SM_BCQFIL                      = "
  tree.end
  tree "UNUSED_SM_10"
   group.long 0xa8--0xab "UNUSED_SM_10 (at 0x9000a2a8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SM_BCINQ                       = "
  tree.end
  tree "UNUSED_SM_11"
   group.long 0xac--0xaf "UNUSED_SM_11 (at 0x9000a2ac)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   SM_BCQNQ                       = "
  tree.end
  tree "UNUSED_SM_12"
   group.long 0xb0--0xb3 "UNUSED_SM_12 (at 0x9000a2b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SM_BCLOGL                      = "
  tree.end
  tree "UNUSED_SM_13"
   group.long 0xb4--0xb7 "UNUSED_SM_13 (at 0x9000a2b4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   SM_BCLOGM                      = "
  tree.end
  tree "UNUSED_SM_14"
   group.long 0xb8--0xbb "UNUSED_SM_14 (at 0x9000a2b8)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xd 1 "  [13: 0]   SM_RTCL                        = "
  tree.end
  tree "UNUSED_SM_15"
   group.long 0xbc--0xbf "UNUSED_SM_15 (at 0x9000a2bc)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SM_RTCM                        = "
  tree.end
tree.end

base ad:0x90000500
tree "UNUSED_GPS_RTC"
  tree "UNUSED_GPS_RTC_CNT"
   group.long 0x0--0x3 "UNUSED_GPS_RTC_CNT (at 0x90000500)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xf--0x1f 1 "  [31:15]   CNT_1MS                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   CNT_CX32                       = "
  tree.end
  tree "UNUSED_GPS_RTC_CTL"
   group.long 0x4--0x7 "UNUSED_GPS_RTC_CTL (at 0x90000504)   (shadowed - Use hwio_shadow_ptr->UNUSED_GPS_RTC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   DUMP_EN_SEL                    = " "0 (USE_INTERNAL_TIME_TRANSFER_STROBE_THIS_IS_NORMAL_WORKING_MODE),1 (USE_TESTBUS_IN) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TT_LOAD_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TTRANS_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SLAM                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_GPS                      = " "0,1 "
  tree.end
  tree "UNUSED_GPS_RTC_DUMP_STATUS"
   group.long 0x8--0xb "UNUSED_GPS_RTC_DUMP_STATUS (at 0x90000508) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DUMP_STATUS                    = " "0,1 "
  tree.end
  tree "UNUSED_GPS_RTC_TRIG"
   group.long 0xc--0xf "UNUSED_GPS_RTC_TRIG (at 0x9000050c)   (shadowed - Use hwio_shadow_ptr->UNUSED_GPS_RTC_TRIG to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   TRIG_VAL                       = "
  tree.end
  tree "UNUSED_GPS_RTC_LOAD"
   group.long 0x10--0x13 "UNUSED_GPS_RTC_LOAD (at 0x90000510)   (shadowed - Use hwio_shadow_ptr->UNUSED_GPS_RTC_LOAD to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   LOAD_VAL                       = "
  tree.end
  tree "UNUSED_GPS_RTC_DUMP"
   group.long 0x14--0x17 "UNUSED_GPS_RTC_DUMP (at 0x90000514)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DUMP_VAL                       = "
  tree.end
  tree "UNUSED_GPS_RTC_COMP"
   group.long 0x18--0x1b "UNUSED_GPS_RTC_COMP (at 0x90000518)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   COMP_VAL                       = "
  tree.end
tree.end

base ad:0x90003400
tree "UNUSED_PBDEM"
  tree "UNUSED_PB_RESET"
   group.long 0x0--0x3 "UNUSED_PB_RESET (at 0x90003400)   (shadowed - Use hwio_shadow_ptr->UNUSED_PB_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                          = " "0,1 "
  tree.end
  tree "UNUSED_PB_HW_CLK_CTL"
   group.long 0x4--0x7 "UNUSED_PB_HW_CLK_CTL (at 0x90003404)   (shadowed - Use hwio_shadow_ptr->UNUSED_PB_HW_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PBDEM_HW_LCG_EN                = " "0,1 "
  tree.end
  tree "UNUSED_PB_MICRO_CLK_CTL"
   group.long 0x8--0xb "UNUSED_PB_MICRO_CLK_CTL (at 0x90003408)   (shadowed - Use hwio_shadow_ptr->UNUSED_PB_MICRO_CLK_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PBDEM_MICRO_CLK_EN             = " "0,1 "
  tree.end
  tree "UNUSED_PB_CLK_STATUS"
   group.long 0xc--0xf "UNUSED_PB_CLK_STATUS (at 0x9000340c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   PBDEM_CLK_IS_OFF               = " "0,1 "
  tree.end
  tree "UNUSED_PB_MEM_CTL"
   group.long 0x10--0x13 "UNUSED_PB_MEM_CTL (at 0x90003410) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ARM_EN_N                       = " "0,1 "
  tree.end
  tree "UNUSED_PB_MEM_ADDR"
   group.long 0x14--0x17 "UNUSED_PB_MEM_ADDR (at 0x90003414)   (shadowed - Use hwio_shadow_ptr->UNUSED_PB_MEM_ADDR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x14--0x14 "  [   20]   WR_RD_N                        = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   MEM_SEL                        = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   A64B                           = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x0--0xa 1 "  [10: 0]   LOC_ADDR                       = "
  tree.end
  tree "UNUSED_PB_MEM_DATA"
   group.long 0x18--0x1b "UNUSED_PB_MEM_DATA (at 0x90003418) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   MEM_DATA                       = "
  tree.end
tree.end

base ad:0x9000a100
tree "UNUSED_RXF_GPF"
  tree "UNUSED_RXF_GPF_RESET"
   group.long 0x0--0x3 "UNUSED_RXF_GPF_RESET (at 0x9000a100)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SW_RESET                       = " "0,1 "
  tree.end
  tree "UNUSED_RXF_GPF_CTL"
   group.long 0x4--0x7 "UNUSED_RXF_GPF_CTL (at 0x9000a104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   FS_CLK_EN                      = " "0 (TURN_OFF_RX_SAMP_CLK_IN_RXF_SRC),1 (TURN_ON_RX_SAMP_CLK_IN_RXF_SRC) "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   CXN_CLK_EN                     = " "0 (TURN_OFF_RX_FRONT_CLK_AND_CX32_CLK),1 (TURN_ON_RX_FRONT_CLK_AND_CX32_CLK) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   MICRO_DC_OVERRIDE              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   DCC_EN                         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   SPECTRAL_INVERSION             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   EC_Y2_SCALE                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   GREY_MAP_EN                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   ALT_SRC_EN                     = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   RESAMP_BYPASS                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   NOTCH2_EN                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   NOTCH_EN                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PREFILT_BYPASS                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TEST_MODE                      = " "0 (Y1_AND_Y2_INPUTS_FROM_RAMBO),1 (SELECT_INPUT_FORM_TEST_BUS) "
  tree.end
  tree "UNUSED_RXF_GPF_RESAMP_PHASE_MAP0"
   group.long 0x8--0xb "UNUSED_RXF_GPF_RESAMP_PHASE_MAP0 (at 0x9000a108)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESAMP_PHASE_MAP0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
  tree "UNUSED_RXF_GPF_RESAMP_PHASE_MAP1"
   group.long 0xc--0xf "UNUSED_RXF_GPF_RESAMP_PHASE_MAP1 (at 0x9000a10c)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESAMP_PHASE_MAP1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
  tree "UNUSED_RXF_GPF_RESAMP_PHASE_MAP2"
   group.long 0x10--0x13 "UNUSED_RXF_GPF_RESAMP_PHASE_MAP2 (at 0x9000a110)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESAMP_PHASE_MAP2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   PHASE7                         = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   PHASE6                         = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   PHASE5                         = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x13 1 "  [19:16]   PHASE4                         = "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   PHASE3                         = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE2                         = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE1                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE0                         = "
  tree.end
  tree "UNUSED_RXF_GPF_RESAMP_PHASE_MAP3"
   group.long 0x14--0x17 "UNUSED_RXF_GPF_RESAMP_PHASE_MAP3 (at 0x9000a114)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESAMP_PHASE_MAP3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   PHASE10                        = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PHASE9                         = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE8                         = "
  tree.end
  tree "UNUSED_RXF_GPF_RESAMP_END_CNT"
   group.long 0x18--0x1b "UNUSED_RXF_GPF_RESAMP_END_CNT (at 0x9000a118)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_RESAMP_END_CNT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   END_VAL                        = "
  tree.end
  tree "UNUSED_RXF_GPF_COEF"
   group.long 0x1c--0x1f "UNUSED_RXF_GPF_COEF (at 0x9000a11c)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_COEF to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x14 1 "  [20:16]   COMPLEX                        = "
    textline ""
    hexmask.long.byte 0x0 0xb--0xf 1 "  [15:11]   DROOP                          = "
    textline ""
    bitfld.long 0x0 0x8--0xa "  [10: 8]   GAIN_SEL                       = " "0 (NO_LEFT_SHIFT_OR_RIGHT_SHIFT),1 (LEFT_SHIFT_BY_1_BIT),2 (LEFT_SHIFT_BY_2_BITS),3 (LEFT_SHIFT_BY_3_BITS),4 (reserved),5 (RIGHT_SHIFT_BY_1_BIT),6 (RIGHT_SHIFT_BY_2_BITS),7 (RIGHT_SHIFT_BY_3_BITS) "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   GREY_MAP                       = "
  tree.end
  tree "UNUSED_RXF_GPF_COEF_NOTCH0"
   group.long 0x20--0x23 "UNUSED_RXF_GPF_COEF_NOTCH0 (at 0x9000a120)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_COEF_NOTCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   ROT_I_H                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   ROT_I_L                        = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   ROT_R_H                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ROT_R_L                        = "
  tree.end
  tree "UNUSED_RXF_GPF_COEF_NOTCH1"
   group.long 0x24--0x27 "UNUSED_RXF_GPF_COEF_NOTCH1 (at 0x9000a124)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_COEF_NOTCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   ROT_I_H                        = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   ROT_I_L                        = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   ROT_R_H                        = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   ROT_R_L                        = "
  tree.end
  tree "UNUSED_RXF_GPF_NOTCH_NBIT"
   group.long 0x28--0x2b "UNUSED_RXF_GPF_NOTCH_NBIT (at 0x9000a128)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_NOTCH_NBIT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NOTCH1_NBIT                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NOTCH0_NBIT                    = " "0,1,2,3,4,5,6,7 "
  tree.end
  tree "UNUSED_RXF_GPF_TEST_BUS_SEL"
   group.long 0x2c--0x2f "UNUSED_RXF_GPF_TEST_BUS_SEL (at 0x9000a12c)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_TEST_BUS_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TST_BUS_SEL                    = "
  tree.end
  tree "UNUSED_RXF_GPF_MICRO_DC_OFFSET"
   group.long 0x30--0x33 "UNUSED_RXF_GPF_MICRO_DC_OFFSET (at 0x9000a130)   (shadowed - Use hwio_shadow_ptr->UNUSED_RXF_GPF_MICRO_DC_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xd--0x19 1 "  [25:13]   DC_OFFSET_Q                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   DC_OFFSET_I                    = "
  tree.end
  tree "UNUSED_RXF_GPF_CLK_STATUS"
   group.long 0x34--0x37 "UNUSED_RXF_GPF_CLK_STATUS (at 0x9000a134)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   RX_SAMP_CLK_HALTED             = " "0 (RX_SAMP_CLK_IS_NOT_HALTED),1 (RX_SAMP_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CX32_CLK_HALTED                = " "0 (CX32_CLK_IS_NOT_HALTED),1 (CX32_CLK_IS_HALTED) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   RX_FRONT_CLK_HALTED            = " "0 (RX_FRONT_CLK_IS_NOT_HALTED),1 (RX_FRONT_CLK_IS_HALTED) "
  tree.end
tree.end

base ad:0x90008000
tree "UNUSED_WCDMA_MEM_TEST"
  tree "UNUSED_MODEM_TEST_MEM_ACCESS"
   group.long 0x0--0x3 "UNUSED_MODEM_TEST_MEM_ACCESS (at 0x90008000) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA_BITS31_0                  = "
  tree.end
  tree "UNUSED_MODEM_TEST_MEM_ACCESS_LAST"
   group.long 0xffc--0xfff "UNUSED_MODEM_TEST_MEM_ACCESS_LAST (at 0x90008ffc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA_BITS31_0                  = "
  tree.end
tree.end

base ad:0x9000d200
tree "UNUSED_WCDMA_SAMPLE_SRVR"
  tree "UNUSED_UMTS_SAMPSRV_CTL_SEL"
   group.long 0x4--0x7 "UNUSED_UMTS_SAMPSRV_CTL_SEL (at 0x9000d204) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CTL_SEL                        = " "0 (ARM),1 (MDSP) "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_CLK_DISABLE"
   group.long 0x8--0xb "UNUSED_UMTS_SAMPSRV_CLK_DISABLE (at 0x9000d208) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_DISABLE                    = " "0,1 "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_CLK_STATUS"
   group.long 0xc--0xf "UNUSED_UMTS_SAMPSRV_CLK_STATUS (at 0x9000d20c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CLK_IS_OFF                     = " "0,1 "
  tree.end
 tree "UMTS_SAMPSRV_n_CAPTURE_CTL"
  tree "UNUSED_UMTS_SAMPSRV_0_CAPTURE_CTL"
   group.long 0x10--0x13 "UNUSED_UMTS_SAMPSRV_0_CAPTURE_CTL (at 0x9000d210) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CAPTURE_MODE                   = " "0 (CONTINUOUS),1 (WINDOW) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CAPTURE_EN                     = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_CAPTURE_CTL"
   group.long 0x14--0x17 "UNUSED_UMTS_SAMPSRV_1_CAPTURE_CTL (at 0x9000d214) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   CAPTURE_MODE                   = " "0 (CONTINUOUS),1 (WINDOW) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   CAPTURE_EN                     = " "0 (DISABLE),1 (ENABLE) "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_WIND_START_CTL"
  tree "UNUSED_UMTS_SAMPSRV_0_WIND_START_CTL"
   group.long 0x18--0x1b "UNUSED_UMTS_SAMPSRV_0_WIND_START_CTL (at 0x9000d218) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   START_TYPE                     = " "0 (START_AT_THE_ADDRESS_SPECIFIED_BY_START_ADDR),1 (IMMEDIATE_START) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   START_ADDR                     = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_WIND_START_CTL"
   group.long 0x1c--0x1f "UNUSED_UMTS_SAMPSRV_1_WIND_START_CTL (at 0x9000d21c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   START_TYPE                     = " "0 (START_AT_THE_ADDRESS_SPECIFIED_BY_START_ADDR),1 (IMMEDIATE_START) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   START_ADDR                     = "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_WIND_STOP_CTL"
  tree "UNUSED_UMTS_SAMPSRV_0_WIND_STOP_CTL"
   group.long 0x20--0x23 "UNUSED_UMTS_SAMPSRV_0_WIND_STOP_CTL (at 0x9000d220) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   STOP_TYPE                      = " "0 (STOP_AT_THE_ADDRESS_SPECIFIED_BY_STOP_ADDR),1 (IMMEDIATE_STOP) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   STOP_ADDR                      = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_WIND_STOP_CTL"
   group.long 0x24--0x27 "UNUSED_UMTS_SAMPSRV_1_WIND_STOP_CTL (at 0x9000d224) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc "  [   12]   STOP_TYPE                      = " "0 (STOP_AT_THE_ADDRESS_SPECIFIED_BY_STOP_ADDR),1 (IMMEDIATE_STOP) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   STOP_ADDR                      = "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_SRC_SEL"
  tree "UNUSED_UMTS_SAMPSRV_0_SRC_SEL"
   group.long 0x28--0x2b "UNUSED_UMTS_SAMPSRV_0_SRC_SEL (at 0x9000d228) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   Y1Y2_SEL                       = " "0 (IQ_DATA),1 (Y1Y2) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   ANT_SEL                        = " "0 (ANTENNA0),1 (ANTENNA1) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RTC_SEL                        = " "0 (RTC0),1 (RTC1),2 (RTC2),3 (RTC3) "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_SRC_SEL"
   group.long 0x2c--0x2f "UNUSED_UMTS_SAMPSRV_1_SRC_SEL (at 0x9000d22c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   Y1Y2_SEL                       = " "0 (IQ_DATA),1 (Y1Y2) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   ANT_SEL                        = " "0 (ANTENNA0),1 (ANTENNA1) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RTC_SEL                        = " "0 (RTC0),1 (RTC1),2 (RTC2),3 (RTC3) "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_WIND_STATUS"
  tree "UNUSED_UMTS_SAMPSRV_0_WIND_STATUS"
   group.long 0x30--0x33 "UNUSED_UMTS_SAMPSRV_0_WIND_STATUS (at 0x9000d230)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   START_STATUS                   = " "0 (PRIOR_TO_START),1 (STARTED) "
    textline ""
    hexmask.long.word 0x0 0xd--0x18 1 "  [24:13]   START_ADDR                     = "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   STOP_STATUS                    = " "0 (PRIOR_TO_STOP),1 (STOPPED) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   STOP_ADDR                      = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_WIND_STATUS"
   group.long 0x34--0x37 "UNUSED_UMTS_SAMPSRV_1_WIND_STATUS (at 0x9000d234)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x19 "  [   25]   START_STATUS                   = " "0 (PRIOR_TO_START),1 (STARTED) "
    textline ""
    hexmask.long.word 0x0 0xd--0x18 1 "  [24:13]   START_ADDR                     = "
    textline ""
    bitfld.long 0x0 0xc "  [   12]   STOP_STATUS                    = " "0 (PRIOR_TO_STOP),1 (STOPPED) "
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   STOP_ADDR                      = "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_LATEST_ADDR"
  tree "UNUSED_UMTS_SAMPSRV_0_LATEST_ADDR"
   group.long 0x38--0x3b "UNUSED_UMTS_SAMPSRV_0_LATEST_ADDR (at 0x9000d238)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   DATA                           = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_LATEST_ADDR"
   group.long 0x3c--0x3f "UNUSED_UMTS_SAMPSRV_1_LATEST_ADDR (at 0x9000d23c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xb 1 "  [11: 0]   DATA                           = "
  tree.end
 tree.end
 tree "UMTS_SAMPSRV_n_Y1Y2_CAPTURE_CTL"
  tree "UNUSED_UMTS_SAMPSRV_0_Y1Y2_CAPTURE_CTL"
   group.long 0x40--0x43 "UNUSED_UMTS_SAMPSRV_0_Y1Y2_CAPTURE_CTL (at 0x9000d240) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   MODE                           = " "0 (BURST),1 (CONTINUOUS) "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   TRIG_TIME                      = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_1_Y1Y2_CAPTURE_CTL"
   group.long 0x44--0x47 "UNUSED_UMTS_SAMPSRV_1_Y1Y2_CAPTURE_CTL (at 0x9000d244) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xf "  [   15]   MODE                           = " "0 (BURST),1 (CONTINUOUS) "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   TRIG_TIME                      = "
  tree.end
 tree.end
  tree "UNUSED_UMTS_SAMPSRV_TEST_RAM_ADDR"
   group.long 0x48--0x4b "UNUSED_UMTS_SAMPSRV_TEST_RAM_ADDR (at 0x9000d248) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xd "  [   13]   BUF_SEL                        = " "0 (BUFFER_0),1 (BUFFER_1) "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   RAM_ADDR                       = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_TEST_RAM_DATA"
   group.long 0x4c--0x4f "UNUSED_UMTS_SAMPSRV_TEST_RAM_DATA (at 0x9000d24c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA                           = "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_TESTBUS_ENABLE"
   group.long 0x50--0x53 "UNUSED_UMTS_SAMPSRV_TESTBUS_ENABLE (at 0x9000d250) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TESTBUS_EN                     = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "UNUSED_UMTS_SAMPSRV_SPARE"
   group.long 0x54--0x57 "UNUSED_UMTS_SAMPSRV_SPARE (at 0x9000d254) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DATA                           = "
  tree.end
tree.end

base ad:0x9000d000
tree "UNUSED_WCDMA_STMR"
  tree "UNUSED_STMR_ST_EVENT_CTL"
   group.long 0x4--0x7 "UNUSED_STMR_ST_EVENT_CTL (at 0x9000d004) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x12--0x12 "  [   18]   ST_EVENT_INT                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x11--0x11 "  [   17]   SLEEP_ARM                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   ARM_ST_EVENT                   = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EVENT_TIME                     = "
  tree.end
  tree "UNUSED_STMR_REF_COUNT_MICRO"
   group.long 0xc--0xf "UNUSED_STMR_REF_COUNT_MICRO (at 0x9000d00c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   FRAME_NUM                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   SLOT_REF_COUNT                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   FRAME_REF_COUNT                = "
  tree.end
  tree "UNUSED_STMR_COMBINER_COUNT_MICRO"
   group.long 0x10--0x13 "UNUSED_STMR_COMBINER_COUNT_MICRO (at 0x9000d010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C3_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C2_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C1_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C0_COUNT                       = "
  tree.end
  tree "UNUSED_STMR_COMBINER_COUNT2_MICRO"
   group.long 0x14--0x17 "UNUSED_STMR_COMBINER_COUNT2_MICRO (at 0x9000d014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C8_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C7_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C6_COUNT                       = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C5_COUNT                       = "
  tree.end
  tree "UNUSED_STMR_COMBINER_COUNT3_MICRO"
   group.long 0x18--0x1b "UNUSED_STMR_COMBINER_COUNT3_MICRO (at 0x9000d018)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C12_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C11_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C10_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C9_COUNT                       = "
  tree.end
  tree "UNUSED_STMR_COMBINER_COUNT4_MICRO"
   group.long 0x1c--0x1f "UNUSED_STMR_COMBINER_COUNT4_MICRO (at 0x9000d01c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C16_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C15_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C14_COUNT                      = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C13_COUNT                      = "
  tree.end
  tree "UNUSED_STMR_WALL_TIME_MODIFIER"
   group.long 0x20--0x23 "UNUSED_STMR_WALL_TIME_MODIFIER (at 0x9000d020)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_WALL_TIME_MODIFIER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   WALL_TIME_MODIFIER             = "
  tree.end
  tree "UNUSED_STMR_TX_10MS_INT_OFFSET"
   group.long 0x28--0x2b "UNUSED_STMR_TX_10MS_INT_OFFSET (at 0x9000d028)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_TX_10MS_INT_OFFSET to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TX_10MS_INT_OFFSET             = "
  tree.end
  tree "UNUSED_STMR_REF_COUNT_STATUS_MICRO"
   group.long 0x2c--0x2f "UNUSED_STMR_REF_COUNT_STATUS_MICRO (at 0x9000d02c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x17 "  [23:22]   FRAME_NUM                      = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x13--0x15 "  [21:19]   SLOT_REF_COUNT                 = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   FRAME_REF_COUNT                = "
  tree.end
  tree "UNUSED_STMR_TX_TIME_STATUS_MICRO"
   group.long 0x30--0x33 "UNUSED_STMR_TX_TIME_STATUS_MICRO (at 0x9000d030)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x16--0x18 "  [24:22]   TX_SLOT_COUNT                  = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x13--0x15 "  [21:19]   TX_TTI_COUNT                   = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   TX_FRAME_COUNT                 = "
  tree.end
 tree "STMR_Cd_COUNT_STATUS_MICRO"
  tree "UNUSED_STMR_C0_COUNT_STATUS_MICRO"
   group.long 0x34--0x37 "UNUSED_STMR_C0_COUNT_STATUS_MICRO (at 0x9000d034)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C1_COUNT_STATUS_MICRO"
   group.long 0x38--0x3b "UNUSED_STMR_C1_COUNT_STATUS_MICRO (at 0x9000d038)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C2_COUNT_STATUS_MICRO"
   group.long 0x3c--0x3f "UNUSED_STMR_C2_COUNT_STATUS_MICRO (at 0x9000d03c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C3_COUNT_STATUS_MICRO"
   group.long 0x40--0x43 "UNUSED_STMR_C3_COUNT_STATUS_MICRO (at 0x9000d040)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C4_COUNT_STATUS_MICRO"
   group.long 0x44--0x47 "UNUSED_STMR_C4_COUNT_STATUS_MICRO (at 0x9000d044)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C5_COUNT_STATUS_MICRO"
   group.long 0x48--0x4b "UNUSED_STMR_C5_COUNT_STATUS_MICRO (at 0x9000d048)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C6_COUNT_STATUS_MICRO"
   group.long 0x4c--0x4f "UNUSED_STMR_C6_COUNT_STATUS_MICRO (at 0x9000d04c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C7_COUNT_STATUS_MICRO"
   group.long 0x50--0x53 "UNUSED_STMR_C7_COUNT_STATUS_MICRO (at 0x9000d050)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C8_COUNT_STATUS_MICRO"
   group.long 0x54--0x57 "UNUSED_STMR_C8_COUNT_STATUS_MICRO (at 0x9000d054)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C9_COUNT_STATUS_MICRO"
   group.long 0x58--0x5b "UNUSED_STMR_C9_COUNT_STATUS_MICRO (at 0x9000d058)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C10_COUNT_STATUS_MICRO"
   group.long 0x5c--0x5f "UNUSED_STMR_C10_COUNT_STATUS_MICRO (at 0x9000d05c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C11_COUNT_STATUS_MICRO"
   group.long 0x60--0x63 "UNUSED_STMR_C11_COUNT_STATUS_MICRO (at 0x9000d060)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C12_COUNT_STATUS_MICRO"
   group.long 0x64--0x67 "UNUSED_STMR_C12_COUNT_STATUS_MICRO (at 0x9000d064)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C13_COUNT_STATUS_MICRO"
   group.long 0x68--0x6b "UNUSED_STMR_C13_COUNT_STATUS_MICRO (at 0x9000d068)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C14_COUNT_STATUS_MICRO"
   group.long 0x6c--0x6f "UNUSED_STMR_C14_COUNT_STATUS_MICRO (at 0x9000d06c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C15_COUNT_STATUS_MICRO"
   group.long 0x70--0x73 "UNUSED_STMR_C15_COUNT_STATUS_MICRO (at 0x9000d070)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
  tree "UNUSED_STMR_C16_COUNT_STATUS_MICRO"
   group.long 0x74--0x77 "UNUSED_STMR_C16_COUNT_STATUS_MICRO (at 0x9000d074)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   CD_COUNT_STATUS                = "
  tree.end
 tree.end
  tree "UNUSED_STMR_CFN_COUNT_MICRO"
   group.long 0x78--0x7b "UNUSED_STMR_CFN_COUNT_MICRO (at 0x9000d078)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C3_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C2_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C1_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C0_CFN_COUNT                   = "
  tree.end
  tree "UNUSED_STMR_CFN_COUNT2_MICRO"
   group.long 0x7c--0x7f "UNUSED_STMR_CFN_COUNT2_MICRO (at 0x9000d07c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C8_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C7_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C6_CFN_COUNT                   = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C5_CFN_COUNT                   = "
  tree.end
  tree "UNUSED_STMR_CFN_COUNT3_MICRO"
   group.long 0x80--0x83 "UNUSED_STMR_CFN_COUNT3_MICRO (at 0x9000d080)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C12_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C11_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C10_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C9_CFN_COUNT                   = "
  tree.end
  tree "UNUSED_STMR_CFN_COUNT4_MICRO"
   group.long 0x84--0x87 "UNUSED_STMR_CFN_COUNT4_MICRO (at 0x9000d084)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C16_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C15_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C14_CFN_COUNT                  = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C13_CFN_COUNT                  = "
  tree.end
  tree "UNUSED_STMR_C4_COUNT_MICRO"
   group.long 0x88--0x8b "UNUSED_STMR_C4_COUNT_MICRO (at 0x9000d088)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C4_COUNT                       = "
  tree.end
  tree "UNUSED_STMR_C4_CFN_MICRO"
   group.long 0x8c--0x8f "UNUSED_STMR_C4_CFN_MICRO (at 0x9000d08c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C4_CFN_COUNT                   = "
  tree.end
  tree "UNUSED_STMR_PROG_INT0_STATUS"
   group.long 0x90--0x93 "UNUSED_STMR_PROG_INT0_STATUS (at 0x9000d090)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INT0_STATUS                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT1_STATUS"
   group.long 0x94--0x97 "UNUSED_STMR_PROG_INT1_STATUS (at 0x9000d094)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT1_STATUS                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT2_STATUS"
   group.long 0x98--0x9b "UNUSED_STMR_PROG_INT2_STATUS (at 0x9000d098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT2_STATUS                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT3_STATUS"
   group.long 0x9c--0x9f "UNUSED_STMR_PROG_INT3_STATUS (at 0x9000d09c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT3_STATUS                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT0_CTL"
   group.long 0xb0--0xb3 "UNUSED_STMR_PROG_INT0_CTL (at 0x9000d0b0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   INT0_REF_SEL                   = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INT0_OFFSET                    = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INT0_ENABLE                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT1_CTL"
   group.long 0xb4--0xb7 "UNUSED_STMR_PROG_INT1_CTL (at 0x9000d0b4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1c 1 "  [28:24]   INT1_REF_SEL                   = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INT1_OFFSET                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BIT15_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT1_ENABLE                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT2_CTL"
   group.long 0xb8--0xbb "UNUSED_STMR_PROG_INT2_CTL (at 0x9000d0b8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x18--0x18 "  [   24]   INT2_REF_SEL                   = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INT2_OFFSET                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BIT15_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT2_ENABLE                    = "
  tree.end
  tree "UNUSED_STMR_PROG_INT3_CTL"
   group.long 0xbc--0xbf "UNUSED_STMR_PROG_INT3_CTL (at 0x9000d0bc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   INT3_REF_SEL                   = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   INT3_OFFSET                    = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   UNDEFINED_BIT15_8              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   INT3_ENABLE                    = "
  tree.end
 tree "STMR_INT0_EVENT_n"
  tree "UNUSED_STMR_INT0_EVENT_0"
   group.long 0xc0--0xc3 "UNUSED_STMR_INT0_EVENT_0 (at 0x9000d0c0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_1"
   group.long 0xc4--0xc7 "UNUSED_STMR_INT0_EVENT_1 (at 0x9000d0c4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_2"
   group.long 0xc8--0xcb "UNUSED_STMR_INT0_EVENT_2 (at 0x9000d0c8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_3"
   group.long 0xcc--0xcf "UNUSED_STMR_INT0_EVENT_3 (at 0x9000d0cc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_4"
   group.long 0xd0--0xd3 "UNUSED_STMR_INT0_EVENT_4 (at 0x9000d0d0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_5"
   group.long 0xd4--0xd7 "UNUSED_STMR_INT0_EVENT_5 (at 0x9000d0d4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_6"
   group.long 0xd8--0xdb "UNUSED_STMR_INT0_EVENT_6 (at 0x9000d0d8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_7"
   group.long 0xdc--0xdf "UNUSED_STMR_INT0_EVENT_7 (at 0x9000d0dc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_8"
   group.long 0xe0--0xe3 "UNUSED_STMR_INT0_EVENT_8 (at 0x9000d0e0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_9"
   group.long 0xe4--0xe7 "UNUSED_STMR_INT0_EVENT_9 (at 0x9000d0e4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_10"
   group.long 0xe8--0xeb "UNUSED_STMR_INT0_EVENT_10 (at 0x9000d0e8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_11"
   group.long 0xec--0xef "UNUSED_STMR_INT0_EVENT_11 (at 0x9000d0ec) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_12"
   group.long 0xf0--0xf3 "UNUSED_STMR_INT0_EVENT_12 (at 0x9000d0f0) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_13"
   group.long 0xf4--0xf7 "UNUSED_STMR_INT0_EVENT_13 (at 0x9000d0f4) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_14"
   group.long 0xf8--0xfb "UNUSED_STMR_INT0_EVENT_14 (at 0x9000d0f8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT0_EVENT_15"
   group.long 0xfc--0xff "UNUSED_STMR_INT0_EVENT_15 (at 0x9000d0fc) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
 tree.end
 tree "STMR_INT1_EVENT_n"
  tree "UNUSED_STMR_INT1_EVENT_0"
   group.long 0x100--0x103 "UNUSED_STMR_INT1_EVENT_0 (at 0x9000d100) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_1"
   group.long 0x104--0x107 "UNUSED_STMR_INT1_EVENT_1 (at 0x9000d104) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_2"
   group.long 0x108--0x10b "UNUSED_STMR_INT1_EVENT_2 (at 0x9000d108) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_3"
   group.long 0x10c--0x10f "UNUSED_STMR_INT1_EVENT_3 (at 0x9000d10c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_4"
   group.long 0x110--0x113 "UNUSED_STMR_INT1_EVENT_4 (at 0x9000d110) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_5"
   group.long 0x114--0x117 "UNUSED_STMR_INT1_EVENT_5 (at 0x9000d114) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_6"
   group.long 0x118--0x11b "UNUSED_STMR_INT1_EVENT_6 (at 0x9000d118) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT1_EVENT_7"
   group.long 0x11c--0x11f "UNUSED_STMR_INT1_EVENT_7 (at 0x9000d11c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
 tree.end
 tree "STMR_INT2_EVENT_n"
  tree "UNUSED_STMR_INT2_EVENT_0"
   group.long 0x120--0x123 "UNUSED_STMR_INT2_EVENT_0 (at 0x9000d120) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_1"
   group.long 0x124--0x127 "UNUSED_STMR_INT2_EVENT_1 (at 0x9000d124) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_2"
   group.long 0x128--0x12b "UNUSED_STMR_INT2_EVENT_2 (at 0x9000d128) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_3"
   group.long 0x12c--0x12f "UNUSED_STMR_INT2_EVENT_3 (at 0x9000d12c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_4"
   group.long 0x130--0x133 "UNUSED_STMR_INT2_EVENT_4 (at 0x9000d130) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_5"
   group.long 0x134--0x137 "UNUSED_STMR_INT2_EVENT_5 (at 0x9000d134) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_6"
   group.long 0x138--0x13b "UNUSED_STMR_INT2_EVENT_6 (at 0x9000d138) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT2_EVENT_7"
   group.long 0x13c--0x13f "UNUSED_STMR_INT2_EVENT_7 (at 0x9000d13c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
 tree.end
 tree "STMR_INT3_EVENT_n"
  tree "UNUSED_STMR_INT3_EVENT_0"
   group.long 0x140--0x143 "UNUSED_STMR_INT3_EVENT_0 (at 0x9000d140) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_1"
   group.long 0x144--0x147 "UNUSED_STMR_INT3_EVENT_1 (at 0x9000d144)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_2"
   group.long 0x148--0x14b "UNUSED_STMR_INT3_EVENT_2 (at 0x9000d148)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_3"
   group.long 0x14c--0x14f "UNUSED_STMR_INT3_EVENT_3 (at 0x9000d14c)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_4"
   group.long 0x150--0x153 "UNUSED_STMR_INT3_EVENT_4 (at 0x9000d150)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_5"
   group.long 0x154--0x157 "UNUSED_STMR_INT3_EVENT_5 (at 0x9000d154)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_6"
   group.long 0x158--0x15b "UNUSED_STMR_INT3_EVENT_6 (at 0x9000d158)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
  tree "UNUSED_STMR_INT3_EVENT_7"
   group.long 0x15c--0x15f "UNUSED_STMR_INT3_EVENT_7 (at 0x9000d15c)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_INT3_EVENT_7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   FIRING_TIME                    = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RESERVED_BIT7_0                = "
  tree.end
 tree.end
  tree "UNUSED_STMR_DSP_INT_DELAY"
   group.long 0x160--0x163 "UNUSED_STMR_DSP_INT_DELAY (at 0x9000d160)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_DSP_INT_DELAY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA4_0                        = "
  tree.end
  tree "UNUSED_STMR_TEST_BUS_SEL"
   group.long 0x164--0x167 "UNUSED_STMR_TEST_BUS_SEL (at 0x9000d164)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_TEST_BUS_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   TESTBUS_EN                     = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TESTBUS_SEL                    = "
  tree.end
  tree "UNUSED_STMR_GSM_COUNT_MICRO"
   group.long 0x168--0x16b "UNUSED_STMR_GSM_COUNT_MICRO (at 0x9000d168)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   DATA18_0                       = "
  tree.end
  tree "UNUSED_STMR_WCDMA_COUNT_MICRO"
   group.long 0x16c--0x16f "UNUSED_STMR_WCDMA_COUNT_MICRO (at 0x9000d16c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   DATA24_0                       = "
  tree.end
  tree "UNUSED_STMR_CLK_ENA"
   group.long 0x170--0x173 "UNUSED_STMR_CLK_ENA (at 0x9000d170)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CLK_ENA to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA0                          = " "0,1 "
  tree.end
  tree "UNUSED_STMR_CLK_STATUS"
   group.long 0x174--0x177 "UNUSED_STMR_CLK_STATUS (at 0x9000d174)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DATA0                          = " "0,1 "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER1_MICRO"
   group.long 0x178--0x17b "UNUSED_STMR_CFN_MODIFIER1_MICRO (at 0x9000d178)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER1_MICRO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C3_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C2_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C1_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C0_CFN_MODIFIER                = "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER2_MICRO"
   group.long 0x17c--0x17f "UNUSED_STMR_CFN_MODIFIER2_MICRO (at 0x9000d17c)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER2_MICRO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C4_CFN_MODIFIER                = "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER3_MICRO"
   group.long 0x180--0x183 "UNUSED_STMR_CFN_MODIFIER3_MICRO (at 0x9000d180)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER3_MICRO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C8_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C7_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C6_CFN_MODIFIER                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C5_CFN_MODIFIER                = "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER4_MICRO"
   group.long 0x184--0x187 "UNUSED_STMR_CFN_MODIFIER4_MICRO (at 0x9000d184)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER4_MICRO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C12_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C11_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C10_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C9_CFN_MODIFIER                = "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER5_MICRO"
   group.long 0x188--0x18b "UNUSED_STMR_CFN_MODIFIER5_MICRO (at 0x9000d188)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER5_MICRO to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   C16_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   C15_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   C14_CFN_MODIFIER               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   C13_CFN_MODIFIER               = "
  tree.end
  tree "UNUSED_STMR_CFN_MODIFIER_SEL"
   group.long 0x18c--0x18f "UNUSED_STMR_CFN_MODIFIER_SEL (at 0x9000d18c)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CFN_MODIFIER_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   MODIFIER_SEL                   = " "0,1 "
  tree.end
  tree "UNUSED_STMR_MISC_CTL"
   group.long 0x190--0x193 "UNUSED_STMR_MISC_CTL (at 0x9000d190)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_MISC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   SBI_TRANSFER_UNIT              = " "0,1 "
  tree.end
  tree "UNUSED_STMR_TIME_SYNC_CTL"
   group.long 0x194--0x197 "UNUSED_STMR_TIME_SYNC_CTL (at 0x9000d194)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_TIME_SYNC_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   CN_ON_LINE_LOAD_EN             = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   GPS_CAPTURE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   GSM_CAPTURE_EN                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ON_LINE_START_SEL              = " "0,1 "
  tree.end
  tree "UNUSED_STMR_CN_MODIFIER_ON_LINE"
   group.long 0x198--0x19b "UNUSED_STMR_CN_MODIFIER_ON_LINE (at 0x9000d198)   (shadowed - Use hwio_shadow_ptr->UNUSED_STMR_CN_MODIFIER_ON_LINE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1a 1 "  [26: 0]   CN_MODIFIER_ON_LINE            = "
  tree.end
  tree "UNUSED_STMR_GSM_SYNC_TIME"
   group.long 0x19c--0x19f "UNUSED_STMR_GSM_SYNC_TIME (at 0x9000d19c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   FRAME_NUM                      = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   FRAME_REF_COUNT                = "
  tree.end
  tree "UNUSED_STMR_GPS_SYNC_TIME"
   group.long 0x1a0--0x1a3 "UNUSED_STMR_GPS_SYNC_TIME (at 0x9000d1a0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x13--0x14 "  [20:19]   FRAME_NUM                      = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x0--0x12 1 "  [18: 0]   FRAME_REF_COUNT                = "
  tree.end
tree.end

base ad:0x9000b000
tree "UNUSED_WCDMA_TX"
 tree "TX_TRBLK_PARAM_TRCHc"
  tree "UNUSED_TX_TRBLK_PARAM_TRCH0"
   group.long 0x0--0x3 "UNUSED_TX_TRBLK_PARAM_TRCH0 (at 0x9000b000)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH1"
   group.long 0x4--0x7 "UNUSED_TX_TRBLK_PARAM_TRCH1 (at 0x9000b004)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH2"
   group.long 0x8--0xb "UNUSED_TX_TRBLK_PARAM_TRCH2 (at 0x9000b008)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH3"
   group.long 0xc--0xf "UNUSED_TX_TRBLK_PARAM_TRCH3 (at 0x9000b00c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH4"
   group.long 0x10--0x13 "UNUSED_TX_TRBLK_PARAM_TRCH4 (at 0x9000b010)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH5"
   group.long 0x14--0x17 "UNUSED_TX_TRBLK_PARAM_TRCH5 (at 0x9000b014)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH6"
   group.long 0x18--0x1b "UNUSED_TX_TRBLK_PARAM_TRCH6 (at 0x9000b018)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
  tree "UNUSED_TX_TRBLK_PARAM_TRCH7"
   group.long 0x1c--0x1f "UNUSED_TX_TRBLK_PARAM_TRCH7 (at 0x9000b01c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRBLK_PARAM_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1c 1 "  [28:16]   TRBLK_SIZE                     = "
    textline ""
    bitfld.long 0x0 0xd--0xf "  [15:13]   RESERVED_BIT15_13              = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xc 1 "  [12: 8]   CRC_SIZE                       = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   NUM_TRBLKS                     = "
  tree.end
 tree.end
 tree "TX_ERAMB_ADDR_TRCHc"
  tree "UNUSED_TX_ERAMB_ADDR_TRCH0"
   group.long 0x20--0x23 "UNUSED_TX_ERAMB_ADDR_TRCH0 (at 0x9000b020)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH1"
   group.long 0x24--0x27 "UNUSED_TX_ERAMB_ADDR_TRCH1 (at 0x9000b024)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH2"
   group.long 0x28--0x2b "UNUSED_TX_ERAMB_ADDR_TRCH2 (at 0x9000b028)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH3"
   group.long 0x2c--0x2f "UNUSED_TX_ERAMB_ADDR_TRCH3 (at 0x9000b02c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH4"
   group.long 0x30--0x33 "UNUSED_TX_ERAMB_ADDR_TRCH4 (at 0x9000b030)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH5"
   group.long 0x34--0x37 "UNUSED_TX_ERAMB_ADDR_TRCH5 (at 0x9000b034)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH6"
   group.long 0x38--0x3b "UNUSED_TX_ERAMB_ADDR_TRCH6 (at 0x9000b038)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
  tree "UNUSED_TX_ERAMB_ADDR_TRCH7"
   group.long 0x3c--0x3f "UNUSED_TX_ERAMB_ADDR_TRCH7 (at 0x9000b03c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMB_ADDR_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   DATA9_0                        = "
  tree.end
 tree.end
 tree "TX_CODING_PARAM_TRCHc"
  tree "UNUSED_TX_CODING_PARAM_TRCH0"
   group.long 0x40--0x43 "UNUSED_TX_CODING_PARAM_TRCH0 (at 0x9000b040)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH1"
   group.long 0x44--0x47 "UNUSED_TX_CODING_PARAM_TRCH1 (at 0x9000b044)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH2"
   group.long 0x48--0x4b "UNUSED_TX_CODING_PARAM_TRCH2 (at 0x9000b048)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH3"
   group.long 0x4c--0x4f "UNUSED_TX_CODING_PARAM_TRCH3 (at 0x9000b04c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH4"
   group.long 0x50--0x53 "UNUSED_TX_CODING_PARAM_TRCH4 (at 0x9000b050)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH5"
   group.long 0x54--0x57 "UNUSED_TX_CODING_PARAM_TRCH5 (at 0x9000b054)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH6"
   group.long 0x58--0x5b "UNUSED_TX_CODING_PARAM_TRCH6 (at 0x9000b058)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
  tree "UNUSED_TX_CODING_PARAM_TRCH7"
   group.long 0x5c--0x5f "UNUSED_TX_CODING_PARAM_TRCH7 (at 0x9000b05c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODING_PARAM_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   NUM_PRE_RM_BITS                = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   TRCH_TTI                       = " "0 (80MS),1 (40MS),2 (20MS),3 (10MS) "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   RESERVED_BIT13_12              = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   RESERVED_BIT7_2                = "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CODING_RATE_TYPE               = " "0 (1),1 (CONV_1_2_RATE_CODING),2 (CONV_1_3_RATE_CODING),3 (TURBO_1_3_RATE_CODING) "
  tree.end
 tree.end
 tree "TX_CODE_SEG_SIZE_TRCHc"
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH0"
   group.long 0x60--0x63 "UNUSED_TX_CODE_SEG_SIZE_TRCH0 (at 0x9000b060)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH1"
   group.long 0x64--0x67 "UNUSED_TX_CODE_SEG_SIZE_TRCH1 (at 0x9000b064)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH2"
   group.long 0x68--0x6b "UNUSED_TX_CODE_SEG_SIZE_TRCH2 (at 0x9000b068)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH3"
   group.long 0x6c--0x6f "UNUSED_TX_CODE_SEG_SIZE_TRCH3 (at 0x9000b06c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH4"
   group.long 0x70--0x73 "UNUSED_TX_CODE_SEG_SIZE_TRCH4 (at 0x9000b070)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH5"
   group.long 0x74--0x77 "UNUSED_TX_CODE_SEG_SIZE_TRCH5 (at 0x9000b074)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH6"
   group.long 0x78--0x7b "UNUSED_TX_CODE_SEG_SIZE_TRCH6 (at 0x9000b078)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_CODE_SEG_SIZE_TRCH7"
   group.long 0x7c--0x7f "UNUSED_TX_CODE_SEG_SIZE_TRCH7 (at 0x9000b07c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CODE_SEG_SIZE_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   PUNCTURE_FLAG                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x16--0x1e 1 "  [30:22]   RESERVED_BIT30_22              = "
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
 tree.end
 tree "TX_RM_EINI_TRCHc"
  tree "UNUSED_TX_RM_EINI_TRCH0"
   group.long 0x80--0x83 "UNUSED_TX_RM_EINI_TRCH0 (at 0x9000b080)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH1"
   group.long 0x84--0x87 "UNUSED_TX_RM_EINI_TRCH1 (at 0x9000b084)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH2"
   group.long 0x88--0x8b "UNUSED_TX_RM_EINI_TRCH2 (at 0x9000b088)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH3"
   group.long 0x8c--0x8f "UNUSED_TX_RM_EINI_TRCH3 (at 0x9000b08c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH4"
   group.long 0x90--0x93 "UNUSED_TX_RM_EINI_TRCH4 (at 0x9000b090)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH5"
   group.long 0x94--0x97 "UNUSED_TX_RM_EINI_TRCH5 (at 0x9000b094)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH6"
   group.long 0x98--0x9b "UNUSED_TX_RM_EINI_TRCH6 (at 0x9000b098)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
  tree "UNUSED_TX_RM_EINI_TRCH7"
   group.long 0x9c--0x9f "UNUSED_TX_RM_EINI_TRCH7 (at 0x9000b09c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EINI_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   INITIAL_ERROR2                 = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   INITIAL_ERROR1                 = "
  tree.end
 tree.end
 tree "TX_RM_EMINUS_TRCHc"
  tree "UNUSED_TX_RM_EMINUS_TRCH0"
   group.long 0xa0--0xa3 "UNUSED_TX_RM_EMINUS_TRCH0 (at 0x9000b0a0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH1"
   group.long 0xa4--0xa7 "UNUSED_TX_RM_EMINUS_TRCH1 (at 0x9000b0a4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH2"
   group.long 0xa8--0xab "UNUSED_TX_RM_EMINUS_TRCH2 (at 0x9000b0a8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH3"
   group.long 0xac--0xaf "UNUSED_TX_RM_EMINUS_TRCH3 (at 0x9000b0ac)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH4"
   group.long 0xb0--0xb3 "UNUSED_TX_RM_EMINUS_TRCH4 (at 0x9000b0b0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH5"
   group.long 0xb4--0xb7 "UNUSED_TX_RM_EMINUS_TRCH5 (at 0x9000b0b4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH6"
   group.long 0xb8--0xbb "UNUSED_TX_RM_EMINUS_TRCH6 (at 0x9000b0b8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
  tree "UNUSED_TX_RM_EMINUS_TRCH7"
   group.long 0xbc--0xbf "UNUSED_TX_RM_EMINUS_TRCH7 (at 0x9000b0bc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EMINUS_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EMINUS2                        = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EMINUS1                        = "
  tree.end
 tree.end
 tree "TX_RM_EPLUS_TRCHc"
  tree "UNUSED_TX_RM_EPLUS_TRCH0"
   group.long 0xc0--0xc3 "UNUSED_TX_RM_EPLUS_TRCH0 (at 0x9000b0c0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH1"
   group.long 0xc4--0xc7 "UNUSED_TX_RM_EPLUS_TRCH1 (at 0x9000b0c4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH2"
   group.long 0xc8--0xcb "UNUSED_TX_RM_EPLUS_TRCH2 (at 0x9000b0c8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH3"
   group.long 0xcc--0xcf "UNUSED_TX_RM_EPLUS_TRCH3 (at 0x9000b0cc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH4"
   group.long 0xd0--0xd3 "UNUSED_TX_RM_EPLUS_TRCH4 (at 0x9000b0d0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH5"
   group.long 0xd4--0xd7 "UNUSED_TX_RM_EPLUS_TRCH5 (at 0x9000b0d4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH6"
   group.long 0xd8--0xdb "UNUSED_TX_RM_EPLUS_TRCH6 (at 0x9000b0d8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
  tree "UNUSED_TX_RM_EPLUS_TRCH7"
   group.long 0xdc--0xdf "UNUSED_TX_RM_EPLUS_TRCH7 (at 0x9000b0dc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_RM_EPLUS_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   EPLUS2                         = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   EPLUS1                         = "
  tree.end
 tree.end
 tree "TX_TURBO_INTLV_PARAM0_TRCHc"
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH0"
   group.long 0xe0--0xe3 "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH0 (at 0x9000b0e0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH1"
   group.long 0xe4--0xe7 "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH1 (at 0x9000b0e4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH2"
   group.long 0xe8--0xeb "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH2 (at 0x9000b0e8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH3"
   group.long 0xec--0xef "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH3 (at 0x9000b0ec)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH4"
   group.long 0xf0--0xf3 "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH4 (at 0x9000b0f0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH5"
   group.long 0xf4--0xf7 "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH5 (at 0x9000b0f4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH6"
   group.long 0xf8--0xfb "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH6 (at 0x9000b0f8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH7"
   group.long 0xfc--0xff "UNUSED_TX_TURBO_INTLV_PARAM0_TRCH7 (at 0x9000b0fc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM0_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0xe--0xf "  [15:14]   RESERVED_BIT15_14              = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0xc--0xd "  [13:12]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x9--0xb "  [11: 9]   RESERVED_BIT11_9               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BIT7_5                = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
 tree.end
 tree "TX_TURBO_INTLV_PARAM1_TRCHc"
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH0"
   group.long 0x100--0x103 "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH0 (at 0x9000b100)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH1"
   group.long 0x104--0x107 "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH1 (at 0x9000b104)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH2"
   group.long 0x108--0x10b "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH2 (at 0x9000b108)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH3"
   group.long 0x10c--0x10f "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH3 (at 0x9000b10c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH4"
   group.long 0x110--0x113 "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH4 (at 0x9000b110)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH5"
   group.long 0x114--0x117 "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH5 (at 0x9000b114)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH6"
   group.long 0x118--0x11b "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH6 (at 0x9000b118)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH7"
   group.long 0x11c--0x11f "UNUSED_TX_TURBO_INTLV_PARAM1_TRCH7 (at 0x9000b11c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TURBO_INTLV_PARAM1_TRCH7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x10--0x15 1 "  [21:16]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.byte 0x0 0x9--0xf 1 "  [15: 9]   RESERVED_BIT15_9               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
 tree.end
  tree "UNUSED_TX_TRCH_MUX_ORDER"
   group.long 0x120--0x123 "UNUSED_TX_TRCH_MUX_ORDER (at 0x9000b120)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TRCH_MUX_ORDER to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x10--0x12 "  [18:16]   TRCH_CFG1_INDEX                = " "0 (0),1 (1),2 (2),3 (3),4 (4),5 (5),6 (6),7 (7) "
    textline ""
    hexmask.long.byte 0x0 0xa--0xf 1 "  [15:10]   RESERVED_BIT15_10              = "
    textline ""
    hexmask.long.word 0x0 0x0--0x9 1 "  [ 9: 0]   TRCH_START_ADDR                = "
  tree.end
  tree "UNUSED_TX_ENC_TIMING_CTL"
   group.long 0x12c--0x12f "UNUSED_TX_ENC_TIMING_CTL (at 0x9000b12c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ENC_TIMING_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   START_ENC_NOW                  = " "0,1 "
    textline ""
    hexmask.long.word 0x0 0x10--0x1e 1 "  [30:16]   RESERVED_BIT30_16              = "
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   START_ENC_TIME                 = "
  tree.end
  tree "UNUSED_TX_ERAM_AB_TRCHS"
   group.long 0x130--0x133 "UNUSED_TX_ERAM_AB_TRCHS (at 0x9000b130)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAM_AB_TRCHS to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   NUM_ACTIVE_TRCHS               = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   RESERVED_BIT7_4                = "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NUM_ERAMA_TRCHS                = "
  tree.end
  tree "UNUSED_TX_DPDCH_OVSF_NUM"
   group.long 0x138--0x13b "UNUSED_TX_DPDCH_OVSF_NUM (at 0x9000b138)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_DPDCH_OVSF_NUM to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TX_DPDCH_OVSF_NUM              = "
  tree.end
  tree "UNUSED_TX_DATA_SPR_FACTOR"
   group.long 0x13c--0x13f "UNUSED_TX_DATA_SPR_FACTOR (at 0x9000b13c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_DATA_SPR_FACTOR to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TX_DATA_SPR_FACTOR             = " "0 (2),1 (4),2 (8),3 (16),4 (32),5 (64),6 (128),7 (256) "
  tree.end
  tree "UNUSED_TX_SCR_CODE_INIT"
   group.long 0x140--0x143 "UNUSED_TX_SCR_CODE_INIT (at 0x9000b140)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_SCR_CODE_INIT to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   SCR_CODE_TYPE                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x19--0x1e 1 "  [30:25]   RESERVED_BIT30_25              = "
    textline ""
    hexmask.long.long 0x0 0x0--0x18 1 "  [24: 0]   SCR_CODE_INIT                  = "
  tree.end
  tree "UNUSED_TX_BETA_GAIN_0"
   group.long 0x144--0x147 "UNUSED_TX_BETA_GAIN_0 (at 0x9000b144)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_BETA_GAIN_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0xf--0x1d 1 "  [29:15]   SPR_GAIN_DATA                  = "
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   SPR_GAIN_CTL                   = "
  tree.end
  tree "UNUSED_TX_BETA_GAIN_1"
   group.long 0x148--0x14b "UNUSED_TX_BETA_GAIN_1 (at 0x9000b148)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_BETA_GAIN_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0xe 1 "  [14: 0]   SPR_GAIN_PREAMBLE              = "
  tree.end
  tree "UNUSED_TX_PHY_CH_TYPE"
   group.long 0x14c--0x14f "UNUSED_TX_PHY_CH_TYPE (at 0x9000b14c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_PHY_CH_TYPE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TX_PHY_CH_TYPE                 = " "0 (ABORT_MODE),1 (DPCH),2 (RACH),3 (CPCH) "
  tree.end
  tree "UNUSED_TX_GENERAL_CTL"
   group.long 0x150--0x153 "UNUSED_TX_GENERAL_CTL (at 0x9000b150)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_GENERAL_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   TXC_ENABLE_OVERRIDE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   EUL_LITTLE_ENDIAN              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   CX32_INTF_EN                   = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   MDSP_BETA_GAIN_CTL             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   ERAM_BURST_INTF_EN             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LITTLE_ENDIAN                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   PHASE_ACC_BYPASS               = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   CORDIC_BYPASS                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   TX_SPECTRAL_INVERSION          = " "0,1 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DATA_FORMAT                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   PA_CTL                         = " "0 (OVERRIDE_CLEAR),1 (OVERRIDE_SET),2 (reserved),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   LEGACY_SW_RES_ENA              = " "0,1 "
  tree.end
  tree "UNUSED_TX_ROT_ANGLE_0_CTL"
   group.long 0x154--0x157 "UNUSED_TX_ROT_ANGLE_0_CTL (at 0x9000b154)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ROT_ANGLE_0_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x9--0x11 1 "  [17: 9]   PA_STATE01_ANGLE               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PA_STATE00_ANGLE               = "
  tree.end
  tree "UNUSED_TX_ROT_ANGLE_1_CTL"
   group.long 0x158--0x15b "UNUSED_TX_ROT_ANGLE_1_CTL (at 0x9000b158)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ROT_ANGLE_1_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x9--0x11 1 "  [17: 9]   PA_STATE11_ANGLE               = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PA_STATE10_ANGLE               = "
  tree.end
  tree "UNUSED_TX_TEST_CTL"
   group.long 0x15c--0x15f "UNUSED_TX_TEST_CTL (at 0x9000b15c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_CTL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9--0xa "  [10: 9]   TEST_TONE_SEL                  = " "0 (FCHIP_4_TEST_TONE),1 (FCHIP_8_TEST_TONE),2 (FCHIP_16_TEST_TONE),3 (reserved) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   TX_TEST_BUS_MISR_SEL           = " "0 (TEST_BUS),1 (MISR_OUTPUT_LATCHED_BY_REGISTER_TX_TEST_MISR_ENABLE_OR_LATCH_BY_CHIP_SLOT_STROBES) "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   TX_TEST_BUS_EN                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   TX_TEST_BUS_SEL                = "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   TX_CLK_INVERT                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   SET_IQ_HIGH                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   TX_TONE_ENA                    = " "0,1 "
  tree.end
  tree "UNUSED_TX_ERAMA_DATA_BASE"
   group.long 0x160--0x163 "UNUSED_TX_ERAMA_DATA_BASE (at 0x9000b160)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMA_DATA_BASE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   ERAMA_DATA                     = "
  tree.end
  tree "UNUSED_TX_ERAMA_DATA_END"
   group.long 0x83c--0x83f "UNUSED_TX_ERAMA_DATA_END (at 0x9000b83c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_ERAMA_DATA_END to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   ERAMA_DATA                     = "
  tree.end
 tree "TX_CIPHER_CK0_m"
  tree "UNUSED_TX_CIPHER_CK0_0"
   group.long 0x840--0x843 "UNUSED_TX_CIPHER_CK0_0 (at 0x9000b840)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK0_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK0_1"
   group.long 0x844--0x847 "UNUSED_TX_CIPHER_CK0_1 (at 0x9000b844)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK0_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK0_2"
   group.long 0x848--0x84b "UNUSED_TX_CIPHER_CK0_2 (at 0x9000b848)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK0_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK0_3"
   group.long 0x84c--0x84f "UNUSED_TX_CIPHER_CK0_3 (at 0x9000b84c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK0_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
 tree "TX_CIPHER_CK1_m"
  tree "UNUSED_TX_CIPHER_CK1_0"
   group.long 0x850--0x853 "UNUSED_TX_CIPHER_CK1_0 (at 0x9000b850)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK1_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK1_1"
   group.long 0x854--0x857 "UNUSED_TX_CIPHER_CK1_1 (at 0x9000b854)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK1_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK1_2"
   group.long 0x858--0x85b "UNUSED_TX_CIPHER_CK1_2 (at 0x9000b858)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK1_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK1_3"
   group.long 0x85c--0x85f "UNUSED_TX_CIPHER_CK1_3 (at 0x9000b85c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK1_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
 tree "TX_CIPHER_CK2_m"
  tree "UNUSED_TX_CIPHER_CK2_0"
   group.long 0x860--0x863 "UNUSED_TX_CIPHER_CK2_0 (at 0x9000b860)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK2_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK2_1"
   group.long 0x864--0x867 "UNUSED_TX_CIPHER_CK2_1 (at 0x9000b864)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK2_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK2_2"
   group.long 0x868--0x86b "UNUSED_TX_CIPHER_CK2_2 (at 0x9000b868)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK2_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK2_3"
   group.long 0x86c--0x86f "UNUSED_TX_CIPHER_CK2_3 (at 0x9000b86c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK2_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
 tree "TX_CIPHER_CK3_m"
  tree "UNUSED_TX_CIPHER_CK3_0"
   group.long 0x870--0x873 "UNUSED_TX_CIPHER_CK3_0 (at 0x9000b870)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK3_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK3_1"
   group.long 0x874--0x877 "UNUSED_TX_CIPHER_CK3_1 (at 0x9000b874)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK3_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK3_2"
   group.long 0x878--0x87b "UNUSED_TX_CIPHER_CK3_2 (at 0x9000b878)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK3_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK3_3"
   group.long 0x87c--0x87f "UNUSED_TX_CIPHER_CK3_3 (at 0x9000b87c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK3_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
 tree "TX_CIPHER_CK4_m"
  tree "UNUSED_TX_CIPHER_CK4_0"
   group.long 0x880--0x883 "UNUSED_TX_CIPHER_CK4_0 (at 0x9000b880)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK4_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK4_1"
   group.long 0x884--0x887 "UNUSED_TX_CIPHER_CK4_1 (at 0x9000b884)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK4_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK4_2"
   group.long 0x888--0x88b "UNUSED_TX_CIPHER_CK4_2 (at 0x9000b888)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK4_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK4_3"
   group.long 0x88c--0x88f "UNUSED_TX_CIPHER_CK4_3 (at 0x9000b88c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK4_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
 tree "TX_CIPHER_CK5_m"
  tree "UNUSED_TX_CIPHER_CK5_0"
   group.long 0x890--0x893 "UNUSED_TX_CIPHER_CK5_0 (at 0x9000b890)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK5_0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK5_1"
   group.long 0x894--0x897 "UNUSED_TX_CIPHER_CK5_1 (at 0x9000b894)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK5_1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK5_2"
   group.long 0x898--0x89b "UNUSED_TX_CIPHER_CK5_2 (at 0x9000b898)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK5_2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
  tree "UNUSED_TX_CIPHER_CK5_3"
   group.long 0x89c--0x89f "UNUSED_TX_CIPHER_CK5_3 (at 0x9000b89c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_CIPHER_CK5_3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   DATA31_0                       = "
  tree.end
 tree.end
  tree "UNUSED_TX_FILLER_POLARITY"
   group.long 0x8a0--0x8a3 "UNUSED_TX_FILLER_POLARITY (at 0x9000b8a0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_FILLER_POLARITY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   RFRM_EQ_FILLER_BIT             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   CODE_SEG_FILLER_BIT            = " "0,1 "
  tree.end
  tree "UNUSED_TX_STATUS"
   group.long 0x8a4--0x8a7 "UNUSED_TX_STATUS (at 0x9000b8a4)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0xb--0xb "  [   11]   EUL_ERAM_CTRL_OVF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   EUL_ERAM_DATA_OVF              = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   EUL_RMRAM_SEL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   EUL_TURBO_ENC_ACTIVE           = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   EUL_CRC_CIPH_ACTIVE            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   EUL_ENC_ERROR                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   PA_STATUS                      = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   TRCH_NUMBER                    = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   ENC_IN_PROGRESS                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ENC_ERROR                      = " "0,1 "
  tree.end
  tree "UNUSED_TX_HW_CLK_CTL"
   group.long 0x8a8--0x8ab "UNUSED_TX_HW_CLK_CTL (at 0x9000b8a8) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   EUL_ENC_HW_LCG_ENA             = " "0 (SW_CTL),1 (HW_CTL) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   EUL_ENC_FEND_HW_LCG_ENA        = " "0 (SW_CTL),1 (HW_CTL) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   TX_CX32_HW_LCG_ENA             = " "0 (SW_CTL_ON_TX_CX_32_CLOCK),1 (HW_CTL_ON_TX_CX_32_CLOCK) "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RESERVED_BIT5_4                = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   FIR_HW_LCG_ENA                 = " "0 (SW_CTL_ON_BB_FILTER),1 (HW_CTL_ON_BB_FILTER) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TENC_HW_LCG_ENA                = " "0 (SW_CTL),1 (HW_CTL) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   ENCODING_HW_LCG_ENA            = " "0 (SW_CTL),1 (HW_CTL) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENC_FEND_HW_LCG_ENA            = " "0 (SW_CTL),1 (HW_CTL) "
  tree.end
  tree "UNUSED_TX_ARM_CLK_CTL"
   group.long 0x8ac--0x8af "UNUSED_TX_ARM_CLK_CTL (at 0x9000b8ac) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   TX_CX16_INTF_CLK_OVERRIDE      = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   EUL_ENC_CLK_OVERRIDE           = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   EUL_ENC_FEND_CLK_OVERRIDE      = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   TX_CX32_CLK_OVERRIDE           = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   TX_CX16_CLK_OVERRIDE           = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   TX_CX8_CLK_OVERRIDE            = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   FIR_CLK_OVERRIDE               = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TENC_CLK_OVERRIDE              = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   ENCODING_CLK_OVERRIDE          = " "0 (CLK_OFF),1 (CLK_ON) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENC_FEND_CLK_OVERRIDE          = " "0 (CLK_OFF),1 (CLK_ON) "
  tree.end
  tree "UNUSED_TX_CLK_STATUS"
   group.long 0x8b0--0x8b3 "UNUSED_TX_CLK_STATUS (at 0x9000b8b0)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x9 "  [    9]   TX_CX16_INTF_CLK_IS_OFF        = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x8 "  [    8]   EUL_ENCODING_CLK_IS_OFF        = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x7 "  [    7]   EUL_ENC_FEND_CLK_IS_OFF        = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x6 "  [    6]   TX_CX32_CLK_IS_OFF             = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   TX_CX16_CLK_IS_OFF             = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   TX_CX8_CLK_IS_OFF              = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   FIR_CLK_IS_OFF                 = " "0 (CLOCK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   TENC_CLK_IS_OFF                = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x1 "  [    1]   ENCODING_CLK_IS_OFF            = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   ENC_FEND_CLK_IS_OFF            = " "0 (CLK_ON),1 (CLK_GATED_OFF) "
  tree.end
  tree "UNUSED_TX_HSDPCCH_OVSF_NUM"
   group.long 0x8b4--0x8b7 "UNUSED_TX_HSDPCCH_OVSF_NUM (at 0x9000b8b4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_HSDPCCH_OVSF_NUM to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TX_HSDPCCH_OVSF_NUM            = "
  tree.end
  tree "UNUSED_TX_VAR_GAIN_SHIFT_DLY"
   group.long 0x8b8--0x8bb "UNUSED_TX_VAR_GAIN_SHIFT_DLY (at 0x9000b8b8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_VAR_GAIN_SHIFT_DLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TX_VAR_GAIN_SHIFT_DLY_VAL      = "
  tree.end
  tree "UNUSED_TX_BETA_GAIN_GROUP_DLY"
   group.long 0x8bc--0x8bf "UNUSED_TX_BETA_GAIN_GROUP_DLY (at 0x9000b8bc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_BETA_GAIN_GROUP_DLY to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TX_BETA_GAIN_GROUP_DLY_VAL     = "
  tree.end
  tree "UNUSED_TX_EUL_ERAM_MEMORY_BANK"
   group.long 0x8c0--0x8c3 "UNUSED_TX_EUL_ERAM_MEMORY_BANK (at 0x9000b8c0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_ERAM_MEMORY_BANK to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   EUL_HARQ_TTI_MODE              = " "0 (2MS_TTI_HARQ_PROCESSES),1 (10MS_TTI_HARQ_PROCESSES) "
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   EUL_SW_WRITE_BANK              = " "0 (BANK0),1 (BANK1),2 (BANK2),3 (BANK3),4 (BANK4),5 (BANK5),6 (BANK6),7 (BANK7) "
  tree.end
  tree "UNUSED_TX_EUL_ERAM_DATA_BASE"
   group.long 0x8c8--0x8cb "UNUSED_TX_EUL_ERAM_DATA_BASE (at 0x9000b8c8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_ERAM_DATA_BASE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   E_ERAM_DATA                    = "
  tree.end
  tree "UNUSED_TX_EUL_ERAM_DATA_END"
   group.long 0x1884--0x1887 "UNUSED_TX_EUL_ERAM_DATA_END (at 0x9000c884)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_ERAM_DATA_END to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   E_ERAM_DATA                    = "
  tree.end
  tree "UNUSED_TX_EUL_ERAM_CTRL_BASE"
   group.long 0x188c--0x188f "UNUSED_TX_EUL_ERAM_CTRL_BASE (at 0x9000c88c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_ERAM_CTRL_BASE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EUL_ERAM_CTRL_WORDS            = "
  tree.end
  tree "UNUSED_TX_EUL_ERAM_CTRL_END"
   group.long 0x1d88--0x1d8b "UNUSED_TX_EUL_ERAM_CTRL_END (at 0x9000cd88)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_ERAM_CTRL_END to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   EUL_ERAM_CTRL_WORDS            = "
  tree.end
 tree "TX_EUL_CODING_PARAM_BANKc"
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK0"
   group.long 0x1d8c--0x1d8f "UNUSED_TX_EUL_CODING_PARAM_BANK0 (at 0x9000cd8c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK1"
   group.long 0x1d90--0x1d93 "UNUSED_TX_EUL_CODING_PARAM_BANK1 (at 0x9000cd90)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK2"
   group.long 0x1d94--0x1d97 "UNUSED_TX_EUL_CODING_PARAM_BANK2 (at 0x9000cd94)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK3"
   group.long 0x1d98--0x1d9b "UNUSED_TX_EUL_CODING_PARAM_BANK3 (at 0x9000cd98)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK4"
   group.long 0x1d9c--0x1d9f "UNUSED_TX_EUL_CODING_PARAM_BANK4 (at 0x9000cd9c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK5"
   group.long 0x1da0--0x1da3 "UNUSED_TX_EUL_CODING_PARAM_BANK5 (at 0x9000cda0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK6"
   group.long 0x1da4--0x1da7 "UNUSED_TX_EUL_CODING_PARAM_BANK6 (at 0x9000cda4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
  tree "UNUSED_TX_EUL_CODING_PARAM_BANK7"
   group.long 0x1da8--0x1dab "UNUSED_TX_EUL_CODING_PARAM_BANK7 (at 0x9000cda8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODING_PARAM_BANK7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x11--0x14 1 "  [20:17]   NUM_CODE_SEGS                  = "
    textline ""
    hexmask.long.long 0x0 0x0--0x10 1 "  [16: 0]   NUM_PRE_RM_BITS                = "
  tree.end
 tree.end
 tree "TX_EUL_CODE_SEG_SIZE_BANKc"
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK0"
   group.long 0x1dac--0x1daf "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK0 (at 0x9000cdac)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK1"
   group.long 0x1db0--0x1db3 "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK1 (at 0x9000cdb0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK2"
   group.long 0x1db4--0x1db7 "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK2 (at 0x9000cdb4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK3"
   group.long 0x1db8--0x1dbb "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK3 (at 0x9000cdb8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK4"
   group.long 0x1dbc--0x1dbf "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK4 (at 0x9000cdbc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK5"
   group.long 0x1dc0--0x1dc3 "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK5 (at 0x9000cdc0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK6"
   group.long 0x1dc4--0x1dc7 "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK6 (at 0x9000cdc4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
  tree "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK7"
   group.long 0x1dc8--0x1dcb "UNUSED_TX_EUL_CODE_SEG_SIZE_BANK7 (at 0x9000cdc8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_CODE_SEG_SIZE_BANK7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0xd--0x12 1 "  [18:13]   NUM_FILLER_BITS                = "
    textline ""
    hexmask.long.word 0x0 0x0--0xc 1 "  [12: 0]   NUM_BITS_CODE_SEG              = "
  tree.end
 tree.end
 tree "TX_EUL_TURBO_INTLV_PARAM0_BANKc"
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK0"
   group.long 0x1dcc--0x1dcf "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK0 (at 0x9000cdcc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK1"
   group.long 0x1dd0--0x1dd3 "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK1 (at 0x9000cdd0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK2"
   group.long 0x1dd4--0x1dd7 "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK2 (at 0x9000cdd4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK3"
   group.long 0x1dd8--0x1ddb "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK3 (at 0x9000cdd8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK4"
   group.long 0x1ddc--0x1ddf "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK4 (at 0x9000cddc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK5"
   group.long 0x1de0--0x1de3 "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK5 (at 0x9000cde0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK6"
   group.long 0x1de4--0x1de7 "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK6 (at 0x9000cde4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK7"
   group.long 0x1de8--0x1deb "UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK7 (at 0x9000cde8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM0_BANK7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   NUM_COLUMNS_MINUS1             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   LAST_COLUMN                    = "
    textline ""
    bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM_ROW_INDEX                  = " "0 (20_ROWS_USE_PA),1 (20_ROWS_USE_PB),2 (10_ROWS_USE_PC),3 (5_ROWS_USE_PD) "
    textline ""
    bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_ROW_BIT_EXCH              = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LAST_ROW                       = "
  tree.end
 tree.end
 tree "TX_EUL_TURBO_INTLV_PARAM1_BANKc"
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK0"
   group.long 0x1dec--0x1def "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK0 (at 0x9000cdec)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK0 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK1"
   group.long 0x1df0--0x1df3 "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK1 (at 0x9000cdf0)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK1 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK2"
   group.long 0x1df4--0x1df7 "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK2 (at 0x9000cdf4)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK2 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK3"
   group.long 0x1df8--0x1dfb "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK3 (at 0x9000cdf8)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK3 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK4"
   group.long 0x1dfc--0x1dff "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK4 (at 0x9000cdfc)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK4 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK5"
   group.long 0x1e00--0x1e03 "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK5 (at 0x9000ce00)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK5 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK6"
   group.long 0x1e04--0x1e07 "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK6 (at 0x9000ce04)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK6 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
  tree "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK7"
   group.long 0x1e08--0x1e0b "UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK7 (at 0x9000ce08)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_EUL_TURBO_INTLV_PARAM1_BANK7 to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x9--0xe 1 "  [14: 9]   PRIME_NUM_INDEX                = "
    textline ""
    hexmask.long.word 0x0 0x0--0x8 1 "  [ 8: 0]   PRIME_NUMBER                   = "
  tree.end
 tree.end
  tree "UNUSED_TX_TEST_MEM_MODE"
   group.long 0x1e0c--0x1e0f "UNUSED_TX_TEST_MEM_MODE (at 0x9000ce0c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_MEM_MODE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   DATA                           = "
  tree.end
  tree "UNUSED_TX_TEST_MEM_SEL"
   group.long 0x1e10--0x1e13 "UNUSED_TX_TEST_MEM_SEL (at 0x9000ce10)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_MEM_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x13 1 "  [19: 0]   DATA                           = "
  tree.end
  tree "UNUSED_TX_TEST_MEM_WORD_SEL"
   group.long 0x1e14--0x1e17 "UNUSED_TX_TEST_MEM_WORD_SEL (at 0x9000ce14)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_MEM_WORD_SEL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   TEST_MEM_WORD_SEL              = " "0 (READ_OUT_LOWER_16_BITS_OF_MEMORY_WORD),1 (READ_OUT_UPPER_16_BITS_OF_MEMORY_WORD) "
  tree.end
  tree "UNUSED_TX_TEST_MISR_ENABLE"
   group.long 0x1e1c--0x1e1f "UNUSED_TX_TEST_MISR_ENABLE (at 0x9000ce1c)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_MISR_ENABLE to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0 "  [    0]   MISR_ENABLE                    = " "0 (DISABLE),1 (ENABLE) "
  tree.end
  tree "UNUSED_TX_TEST_MISR_CTRL"
   group.long 0x1e20--0x1e23 "UNUSED_TX_TEST_MISR_CTRL (at 0x9000ce20)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TEST_MISR_CTRL to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x6--0xd 1 "  [13: 6]   MISR_ENABLE_DLY                = "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   MISR_LATCH_RESOLUTION_SEL      = " "0 (CHIP_RESOLUTION),1 (256_CHIP_RESOLUTION),2 (FRAME),3 (FRAMEZ) "
    textline ""
    bitfld.long 0x0 0x3 "  [    3]   MISR_LATCH_SEL                 = " "0 (NORMAL_MISR_INSTANTANEOUS_VALUE),1 (USE_MISR_LATCHED_VALUE_IT_IS_LATCHED_EVERY_CHIP) "
    textline ""
    bitfld.long 0x0 0x2 "  [    2]   MISR_TX_VALID_START            = " "0 (USE_TX_TEST_MISR_ENABLE),1 (USE_TX_VALID_INTERNAL_SIGNAL_TO_ENABLE_MISR) "
    textline ""
    bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MISR_ENABLE_RESOLUTION         = " "0 (FRAME),1 (FRAMEZ),2 (SLOT_BOUNDARY),3 (reserved) "
  tree.end
  tree "UNUSED_TX_TEST_MISR_VALUE"
   group.long 0x1e24--0x1e27 "UNUSED_TX_TEST_MISR_VALUE (at 0x9000ce24)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0x1f 1 "  [31: 0]   MISR_VALUE                     = "
  tree.end
  tree "UNUSED_TX_TXC_VALID_FALL_TIME"
   group.long 0x1e28--0x1e2b "UNUSED_TX_TXC_VALID_FALL_TIME (at 0x9000ce28)   (shadowed - Use hwio_shadow_ptr->UNUSED_TX_TXC_VALID_FALL_TIME to read/write)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                          = "
  tree.end
tree.end
tree.end

base ad:0x80016000
tree "USB_OTG_HS"
  tree "USB_OTG_HS_ID"
   group.long 0x0--0x3 "USB_OTG_HS_ID (at 0x80016000)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   REVISON                        = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   RESERVED_BIT15                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RESERVED_BIT14                 = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x8--0xd 1 "  [13: 8]   NID                            = "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   RESERVED_BIT7                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   RESERVED_BIT6                  = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ID                             = "
  tree.end
  tree "USB_OTG_HS_HWGENERAL"
   group.long 0x4--0x7 "USB_OTG_HS_HWGENERAL (at 0x80016004)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0xa--0x1f 1 "  [31:10]   RESERVED_BITS31_10             = "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   SM                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x8 "  [ 8: 6]   PHYM                           = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PHYW                           = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   BWT                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CLCK                           = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RT                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_HWHOST"
   group.long 0x8--0xb "USB_OTG_HS_HWHOST (at 0x80016008)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   TTPER                          = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   TTASY                          = "
    textline ""
    hexmask.long.word 0x0 0x4--0xf 1 "  [15: 4]   RESERVED_BITS15_4              = "
    textline ""
    bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   NPORT                          = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   HC                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_HWDEVICE"
   group.long 0xc--0xf "USB_OTG_HS_HWDEVICE (at 0x8001600c)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x6--0x1f 1 "  [31: 6]   RESERVED_BITS31_6              = "
    textline ""
    hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   DEVEP                          = "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   DC                             = " "0,1 "
  tree.end
  tree "USB_OTG_HS_HWTXBUF"
   group.long 0x10--0x13 "USB_OTG_HS_HWTXBUF (at 0x80016010)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   TXLCR                          = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1e 1 "  [30:24]   RESERVED_BITS30_24             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   TXCHANADD                      = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   TXADD                          = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   TCBURST                        = "
  tree.end
  tree "USB_OTG_HS_HWRXBUF"
   group.long 0x14--0x17 "USB_OTG_HS_HWRXBUF (at 0x80016014)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS31_16             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   RX_ADD                         = "
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   RX_BURST                       = "
  tree.end
  tree "USB_OTG_HS_GPTIMER0LD"
   group.long 0x80--0x83 "USB_OTG_HS_GPTIMER0LD (at 0x80016080) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GPTLD                          = "
  tree.end
  tree "USB_OTG_HS_GPTIMER0CTRL"
   group.long 0x84--0x87 "USB_OTG_HS_GPTIMER0CTRL (at 0x80016084) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   GTPRUN                         = " "0 (TIMER_STOP),1 (TIMER_RUN) "
    textline ""
    bitfld.long 0x0 0x1e "  [   30]   GPTRST                         = " "0 (NO_ACTION),1 (LOAD_COUNTER_VALUE) "
    textline ""
    hexmask.long.byte 0x0 0x19--0x1d 1 "  [29:25]   RESERVED_BITS29_25             = "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   GPTMODE                        = " "0 (ONE_SHOT),1 (REPEAT) "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GPTCNT                         = "
  tree.end
  tree "USB_OTG_HS_GPTIMER1LD"
   group.long 0x88--0x8b "USB_OTG_HS_GPTIMER1LD (at 0x80016088) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x18--0x1f 1 "  [31:24]   RESERVED_BITS31_24             = "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GPTLD                          = "
  tree.end
  tree "USB_OTG_HS_GPTIMER1CTRL"
   group.long 0x8c--0x8f "USB_OTG_HS_GPTIMER1CTRL (at 0x8001608c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f "  [   31]   GTPRUN                         = " "0 (TIMER_STOP),1 (TIMER_RUN) "
    textline ""
    bitfld.long 0x0 0x1e "  [   30]   GPTRST                         = " "0 (NO_ACTION),1 (LOAD_COUNTER_VALUE) "
    textline ""
    hexmask.long.byte 0x0 0x19--0x1d 1 "  [29:25]   RESERVED_BITS29_25             = "
    textline ""
    bitfld.long 0x0 0x18 "  [   24]   GPTMODE                        = " "0 (ONE_SHOT),1 (REPEAT) "
    textline ""
    hexmask.long.long 0x0 0x0--0x17 1 "  [23: 0]   GPTCNT                         = "
  tree.end
  tree "USB_OTG_HS_AHB_BURST"
   group.long 0x90--0x93 "USB_OTG_HS_AHB_BURST (at 0x80016090) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   AHB_BURST                      = " "0,1,2,3,4,5,6,7 "
    textline ""
    hexmask.long.long 0x0 0x3--0x1f 1 "  [31: 3]   RESERVED_BITS31_3              = "
  tree.end
  tree "USB_OTG_HS_XTOR_STS"
   group.long 0x94--0x97 "USB_OTG_HS_XTOR_STS (at 0x80016094)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   RESERVED_BIT0                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   GRANT_STOLEN                   = " "0,1 "
    textline ""
    hexmask.long.long 0x0 0x2--0x1f 1 "  [31: 2]   RESERVED_BITS31_2              = "
  tree.end
  tree "USB_OTG_HS_AHB_MODE"
   group.long 0x98--0x9b "USB_OTG_HS_AHB_MODE (at 0x80016098)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   XTOR_BYPASS                    = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   GRANT_STOLEN_CLEAR             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HPROT_MODE                     = " "0,1,2,3 "
    textline ""
    hexmask.long.long 0x0 0x4--0x1f 1 "  [31: 4]   RESERVED_BITS31_4              = "
  tree.end
  tree "USB_OTG_HS_GEN_CONFIG"
   group.long 0x9c--0x9f "USB_OTG_HS_GEN_CONFIG (at 0x8001609c) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USB_OTG_HS_TESTMUX_SEL         = "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   DEV_PE_NAK_CTRL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BITS7_5               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HOST_SIM_TIMERS_EN_STD         = " "0,1 "
    textline ""
    bitfld.long 0x0 0x9--0x9 "  [    9]   HOST_SIM_TIMERS_EN_SUSP        = " "0,1 "
  tree.end
  tree "USB_OTG_HS_CAPLENGTH"
   group.long 0x100--0x103 "USB_OTG_HS_CAPLENGTH (at 0x80016100)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.word 0x0 0x0--0x7 1 "  [ 7: 0]   CAPLENGTH                      = "
  tree.end
  tree "USB_OTG_HS_HCIVERSION"
   group.long 0x102--0x105 "USB_OTG_HS_HCIVERSION (at 0x80016102)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   HCIVERSION                     = "
  tree.end
  tree "USB_OTG_HS_HCSPARAMS"
   group.long 0x104--0x107 "USB_OTG_HS_HCSPARAMS (at 0x80016104)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.byte 0x0 0x1c--0x1f 1 "  [31:28]   RESERVED_BITS31_28             = "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   N_TT                           = "
    textline ""
    hexmask.long.byte 0x0 0x14--0x17 1 "  [23:20]   N_PTT                          = "
    textline ""
    bitfld.long 0x0 0x11--0x13 "  [19:17]   RESERVED_BITS19_17             = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x10--0x10 "  [   16]   PI                             = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0xc--0xf 1 "  [15:12]   N_CC                           = "
    textline ""
    hexmask.long.byte 0x0 0x8--0xb 1 "  [11: 8]   N_PCC                          = "
    textline ""
    bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RESERVED_BITS7_5               = " "0,1,2,3,4,5,6,7 "
    textline ""
    bitfld.long 0x0 0x4--0x4 "  [    4]   PPC                            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   N_PORTS                        = "
  tree.end
  tree "USB_OTG_HS_HCCPARAMS"
   group.long 0x108--0x10b "USB_OTG_HS_HCCPARAMS (at 0x80016108)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x10--0x1f 1 "  [31:16]   RESERVED_BITS31_16             = "
    textline ""
    hexmask.long.word 0x0 0x8--0xf 1 "  [15: 8]   EECP                           = "
    textline ""
    hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   IST                            = "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   RESERVED_BIT3                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x2--0x2 "  [    2]   ASP                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1--0x1 "  [    1]   PFL                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x0--0x0 "  [    0]   ADC                            = " "0,1 "
  tree.end
  tree "USB_OTG_HS_DCIVERSION"
   group.long 0x120--0x123 "USB_OTG_HS_DCIVERSION (at 0x80016120)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x0--0xf 1 "  [15: 0]   DCIVERSION                     = "
  tree.end
  tree "USB_OTG_HS_DCCPARAMS"
   group.long 0x124--0x127 "USB_OTG_HS_DCCPARAMS (at 0x80016124)   (read-only)"
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    hexmask.long.long 0x0 0x9--0x1f 1 "  [31: 9]   RESERVED_BITS31_9              = "
    textline ""
    bitfld.long 0x0 0x8--0x8 "  [    8]   HC                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   DC                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RESERVED_BITS6_5               = " "0,1,2,3 "
    textline ""
    hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DEN                            = "
  tree.end
  tree "USB_OTG_HS_USBCMD"
   group.long 0x140--0x143 "USB_OTG_HS_USBCMD (at 0x80016140) "
    line.long 0x0 "VALUE"
    textline "BITS"
    textline ""
    bitfld.long 0x0 0x1f--0x1f "  [   31]   RST_CTRL                       = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1e--0x1e "  [   30]   ULPI_STP_CTRL                  = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1d--0x1d "  [   29]   ASYNC_INTR_CTRL                = " "0,1 "
    textline ""
    bitfld.long 0x0 0x1c--0x1c "  [   28]   SE0_GLITCH_FIX_CTRL            = " "0,1 "
    textline ""
    hexmask.long.byte 0x0 0x18--0x1b 1 "  [27:24]   RESERVED_BITS27_24             = "
    textline ""
    hexmask.long.word 0x0 0x10--0x17 1 "  [23:16]   ITC                            = "
    textline ""
    bitfld.long 0x0 0xf--0xf "  [   15]   FS2                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0xe--0xe "  [   14]   RESERVED_BIT14                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0xd--0xd "  [   13]   SUTW                           = " "0,1 "
    textline ""
    bitfld.long 0x0 0xc--0xc "  [   12]   ATDTW                          = " "0,1 "
    textline ""
    bitfld.long 0x0 0xb "  [   11]   ASPE                           = " "0 (PARK_MODE_IS_DISABLED),1 (PARK_MODE_IS_ENABLED) "
    textline ""
    bitfld.long 0x0 0xa--0xa "  [   10]   RESERVED_BIT10                 = " "0,1 "
    textline ""
    bitfld.long 0x0 0x8--0x9 "  [ 9: 8]   ASP                            = " "0,1,2,3 "
    textline ""
    bitfld.long 0x0 0x7--0x7 "  [    7]   LR                             = " "0,1 "
    textline ""
    bitfld.long 0x0 0x6--0x6 "  [    6]   IAA                            = " "0,1 "
    textline ""
    bitfld.long 0x0 0x5 "  [    5]   ASE                            = " "0 (DO_NOT_PROCESS_THE_ASYNCHRONOUS_SCHEDULE),1 (USE_THE_ASYNCLISTADDR_REGISTER_TO_ACCESS_THE_ASYNCHRONOUS_SCHEDULE) "
    textline ""
    bitfld.long 0x0 0x4 "  [    4]   PSE                            = " "0 (DO_NOT_PROCESS_THE_PERIODIC_SCHEDULE),1 (USE_THE_PERIODICLISTBASE_REGISTER_TO_ACCESS_THE_PERIODIC_SCHEDULE) "
    textline ""
    bitfld.long 0x0 0x3--0x3 "  [    3]   FS1                            = " "0,1 "
    textline ""
